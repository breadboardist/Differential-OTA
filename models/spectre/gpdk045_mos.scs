+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
12:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 4.0E-8                   lmax = 6.0E-8-dxl_p_lvt                   wmin = 1.0E-6-dxw_p_lvt                   
+wmax = 2.0E-6-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.286351+dvth0_p_lvt  lvth0 = 4.241926E-9+dlvth0_p_lvt wvth0 = 1.849244E-8+dwvth0_p_lvt 
+pvth0 = -1.369535E-15+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.51879E-2              lk2 = -4.419773E-10           wk2 = -9.625274E-10           
+pk2 = 9.439503E-17            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.77783E-2+du0_p_lvt     lu0 = -1.543481E-10+dlu0_p_lvt wu0 = -1.271445E-10+dwu0_p_lvt 
+pu0 = -1.579675E-16+dpu0_p_lvt ua = 1.823818E-11             lua = 0                       
+wua = -6.148913E-18           ub = 1.656104E-18             lub = 5.75153E-26             
+wub = 4.328858E-26            pub = -2.955138E-32           uc = 2.11264E-11              
+wuc = 2.662431E-18            ud = 0                        vsat = 1.082795E5+dvsat_p_lvt 
+lvsat = -8.647195E-4          wvsat = -2.90271E-2           pvsat = 3.128916E-9           
+a0 = 1E-3                     ags = 3.862368                wags = 3.343883E-8            
+b0 = 0                        b1 = 0                        keta = -0.216991              
+lketa = 4.584702E-9           wketa = 3.694816E-7           pketa = -1.872946E-14         
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.115477              lvoff = 4.200668E-9           wvoff = 9.120402E-9           
+pvoff = -7.134778E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.408082            lnfactor = 3.672732E-8        wnfactor = -1.681617E-8       
+pnfactor = -1.513571E-15      eta0 = 3.11538E-2             etab = 0.156383               
+letab = -1.081399E-8          wetab = -6.701428E-8          petab = 4.020857E-15          
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.30818E-2          
+lpdiblc2 = -3.277863E-10      wpdiblc2 = -4.179765E-9       ppdiblc2 = 1.710754E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
13:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_p_lvt                   lmax = 1.1E-5-dxl_p_lvt                   wmin = 5.0E-7-dxw_p_lvt                   
+wmax = 1.0E-6-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.194565+dvth0_p_lvt  lvth0 = 4.176975E-9+dlvth0_p_lvt wvth0 = 8.71504E-10+dwvth0_p_lvt 
+pvth0 = -1.997489E-15+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -7.847288E-3             lk2 = -5.840202E-9            wk2 = -8.219176E-11           
+pk2 = 8.219176E-16            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 0.020731+du0_p_lvt       lu0 = -1.285098E-10+dlu0_p_lvt wu0 = 1.099321E-12+dwu0_p_lvt 
+pu0 = 1.052541E-17+dpu0_p_lvt ua = 1.109496E-11             lua = 8.573662E-18            
+wua = 8.386878E-19            pua = -8.386878E-24           ub = 1.27088E-18              
+lub = -6.928108E-26           wub = -7.457885E-26           pub = 6.633347E-33            
+uc = 9.640722E-11             luc = -1.209172E-16           wuc = -2.252666E-17           
+puc = 4.13755E-23             ud = 0                        vsat = 9.21852E4+dvsat_p_lvt  
+a0 = 2.755215                 la0 = -1.289492E-6            wa0 = -6.166534E-8            
+pa0 = 6.166534E-13            ags = 1.230207                lags = 7.229842E-7            
+wags = -3.047644E-8           pags = -5.225281E-15          b0 = 0                        
+b1 = 0                        keta = -0.124888              lketa = 7.982228E-8           
+wketa = 1.379624E-8           pketa = -3.817215E-14         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -4.27781E-2            lvoff = 5.859945E-9           wvoff = 9.28809E-10           
+pvoff = -2.411488E-15         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.325062            lnfactor = 6.586256E-8        wnfactor = -2.401828E-8       
+pnfactor = 1.71915E-15        eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 0.011707            
+lpdiblc2 = -1.787639E-9       wpdiblc2 = -1.00085E-10       ppdiblc2 = 1.00085E-15        
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
14:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_p_lvt                   lmax = 2.0E-6-dxl_p_lvt                   wmin = 5.0E-7-dxw_p_lvt                   
+wmax = 1.0E-6-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.190146+dvth0_p_lvt  lvth0 = -4.662137E-9+dlvth0_p_lvt wvth0 = -7.484736E-10+dwvth0_p_lvt 
+pvth0 = 1.242466E-15+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.07674E-2              wk2 = 3.28767E-10             k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.06421E-2+du0_p_lvt     lu0 = 4.928014E-11+dlu0_p_lvt wu0 = -3.087454E-12+dwu0_p_lvt 
+pu0 = 1.889896E-17+dpu0_p_lvt ua = 1.538179E-11             wua = -3.354751E-18           
+ub = 1.278187E-18             lub = -8.3896E-26             wub = -1.122963E-25           
+pub = 8.206826E-32            uc = 4.673321E-11             luc = -2.156918E-17           
+wuc = -2.390578E-18           puc = 1.103344E-24            ud = 0                        
+vsat = 9.21852E4+dvsat_p_lvt  a0 = 1.634615                 la0 = 9.517076E-7             
+wa0 = 7.121483E-7             pa0 = -9.309739E-13           ags = 1.114189                
+lags = 9.550194E-7            wags = -2.316245E-8           pags = -1.985326E-14          
+b0 = 0                        b1 = 0                        keta = -8.49774E-2            
+wketa = -5.289837E-9          a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -3.89808E-2            lvoff = -1.734509E-9          wvoff = -4.711641E-10         
+pvoff = 3.884578E-16          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.319765            lnfactor = 7.64562E-8         wnfactor = -2.197986E-8       
+pnfactor = -2.357692E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.704885E-3         
+lpdiblc2 = 2.216519E-9        wpdiblc2 = 1.28803E-9         ppdiblc2 = -1.775379E-15      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
15:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 5.0E-7-dxl_p_lvt                   lmax = 1.0E-6-dxl_p_lvt                   wmin = 5.0E-7-dxw_p_lvt                   
+wmax = 1.0E-6-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.19402+dvth0_p_lvt   lvth0 = -7.883886E-10+dlvth0_p_lvt wvth0 = 1.339768E-9+dwvth0_p_lvt 
+pvth0 = -8.457752E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.07674E-2              wk2 = 3.28767E-10             k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.02118E-2+du0_p_lvt     lu0 = 4.795121E-10+dlu0_p_lvt wu0 = 6.923381E-11+dwu0_p_lvt 
+pu0 = -5.34223E-17+dpu0_p_lvt ua = 1.538179E-11             wua = -3.354751E-18           
+ub = 1.051241E-18             lub = 1.430505E-25            wub = -6.296534E-27           
+pub = -2.393151E-32           uc = 2.516403E-11             wuc = -1.287234E-18           
+ud = 0                        vsat = 9.21852E4+dvsat_p_lvt  a0 = 3.36222                  
+la0 = -7.758967E-7            wa0 = -2.844733E-7            pa0 = 6.564769E-14            
+ags = 1.075988                lags = 9.932204E-7            wags = -2.236813E-8           
+pags = -2.064758E-14          b0 = 0                        b1 = 0                        
+keta = -8.49774E-2            wketa = -5.289837E-9          a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.039418              lvoff = -1.297377E-9          wvoff = 2.582234E-10          
+pvoff = -3.409297E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.322906            lnfactor = 7.331554E-8        wnfactor = -2.578772E-8       
+pnfactor = 1.450168E-15       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.27919E-2          
+lpdiblc2 = -8.704722E-10      wpdiblc2 = -6.790527E-10      ppdiblc2 = 1.917028E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
16:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-7-dxl_p_lvt                   lmax = 5.0E-7-dxl_p_lvt                   wmin = 5.0E-7-dxw_p_lvt                   
+wmax = 1.0E-6-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.189439+dvth0_p_lvt  lvth0 = -3.07881E-9+dlvth0_p_lvt wvth0 = -5.639281E-10+dwvth0_p_lvt 
+pvth0 = 1.060727E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -9.927653E-3             lk2 = -4.198678E-10           wk2 = 3.263111E-10            
+pk2 = 1.227965E-18            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.09695E-2+du0_p_lvt     lu0 = 1.006898E-10+dlu0_p_lvt wu0 = 1.382337E-11+dwu0_p_lvt 
+pu0 = -2.571709E-17+dpu0_p_lvt ua = 1.538179E-11             wua = -3.354751E-18           
+ub = 1.237041E-18             lub = 5.015041E-26            wub = -5.009744E-26           
+pub = -2.031053E-33           uc = 2.516403E-11             wuc = -1.287234E-18           
+ud = 0                        vsat = 9.21852E4+dvsat_p_lvt  a0 = 2.262783                 
+la0 = -2.261783E-7            wa0 = -1.914724E-7            pa0 = 1.914724E-14            
+ags = 2.622622                lags = 2.199035E-7            wags = 1.466587E-7            
+pags = -1.05161E-13           b0 = 0                        b1 = 0                        
+keta = -0.097409              lketa = 6.215849E-9           wketa = -4.722939E-9          
+pketa = -2.834493E-16         a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.037344              lvoff = -2.334359E-9          wvoff = -4.071463E-10         
+pvoff = -8.244905E-18         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.413193            lnfactor = 2.817217E-8        wnfactor = -2.014096E-8       
+pnfactor = -1.373215E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.14519E-2          
+lpdiblc2 = -2.004746E-10      wpdiblc2 = -2.062987E-10      ppdiblc2 = -4.467417E-17      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
17:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 6.0E-8-dxl_p_lvt                   lmax = 1.0E-7-dxl_p_lvt                   wmin = 5.0E-7-dxw_p_lvt                   
+wmax = 1.0E-6-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.217883+dvth0_p_lvt  lvth0 = -2.315703E-10+dlvth0_p_lvt wvth0 = -1.194003E-9+dwvth0_p_lvt 
+pvth0 = 1.690802E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.667648E-3             lk2 = -1.245868E-9            wk2 = 1.095578E-10            
+pk2 = 2.290329E-17            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.93044E-2+du0_p_lvt     lu0 = 2.672019E-10+dlu0_p_lvt wu0 = 1.406683E-9+dwu0_p_lvt  
+pu0 = -1.650031E-16+dpu0_p_lvt ua = 1.538179E-11             wua = -3.354752E-18           
+pua = 8.175722E-32            ub = 8.296347E-19             lub = 9.089101E-26            
+wub = 1.013503E-25            pub = -1.717583E-32           uc = 2.516403E-11             
+wuc = -1.287234E-18           ud = 0                        vsat = 6.855809E4+dvsat_p_lvt 
+lvsat = 2.362711E-3           wvsat = -1.40354E-2           pvsat = 1.403661E-9           
+a0 = 1E-3                     ags = 4.821657                wags = -9.049514E-7           
+b0 = 0                        b1 = 0                        keta = 5.588306E-3            
+lketa = -4.083886E-9          wketa = 9.722906E-9           pketa = -1.728034E-15         
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -8.24351E-2            lvoff = 2.17475E-9            wvoff = 1.870202E-9           
+pvoff = -2.359797E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.194575            lnfactor = 5.003397E-8        wnfactor = -9.483628E-9       
+pnfactor = -2.438948E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 0.012442            
+lpdiblc2 = -2.994882E-10      wpdiblc2 = 1.135027E-10       ppdiblc2 = -7.665432E-17      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
18:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 4.0E-8                   lmax = 6.0E-8-dxl_p_lvt                   wmin = 5.0E-7-dxw_p_lvt                   
+wmax = 1.0E-6-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.267018+dvth0_p_lvt  lvth0 = 2.7165E-9+dlvth0_p_lvt wvth0 = -4.203147E-10+dwvth0_p_lvt 
+pvth0 = 1.226589E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.97479E-2              lk2 = -1.610538E-10           wk2 = 3.498085E-9             
+pk2 = -1.804083E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.82327E-2+du0_p_lvt     lu0 = -2.684997E-10+dlu0_p_lvt wu0 = -5.716553E-10+dwu0_p_lvt 
+pu0 = -4.630277E-17+dpu0_p_lvt ua = 1.538179E-11             wua = -3.35475E-18            
+ub = 1.697597E-18             lub = 3.881325E-26            wub = 2.699781E-27            
+pub = -1.125677E-32           uc = 2.516403E-11             wuc = -1.287234E-18           
+ud = 0                        vsat = 8.355274E4+dvsat_p_lvt lvsat = 1.463182E-3           
+wvsat = -4.838974E-3          pvsat = 8.517292E-10          a0 = 1E-3                     
+ags = 4.821657                wags = -9.049514E-7           b0 = 0                        
+b1 = 0                        keta = 0.241349               lketa = -1.822952E-8          
+wketa = -7.887321E-8          pketa = 3.587733E-15          a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.103675              lvoff = 3.449149E-9           wvoff = -2.423932E-9          
+pvoff = 2.166831E-17          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.411391            lnfactor = 3.702499E-8        wnfactor = -2.005348E-8       
+pnfactor = -1.804757E-15      eta0 = 3.11538E-2             etab = 7.71088E-2             
+letab = -6.057559E-9          wetab = 1.053252E-8           petab = -6.319512E-16         
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 6.678874E-3         
+lpdiblc2 = 4.63003E-11        wpdiblc2 = 2.083621E-9        ppdiblc2 = -1.948614E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
19:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_p_lvt                   lmax = 1.1E-5-dxl_p_lvt                   wmin = 3.0E-7-dxw_p_lvt                   
+wmax = 5.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.193025+dvth0_p_lvt  lvth0 = 2.823875E-9+dlvth0_p_lvt wvth0 = 1.350417E-10+dwvth0_p_lvt 
+pvth0 = -1.350417E-15+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -7.93129E-3              lk2 = -5.000185E-9            wk2 = -4.202092E-11           
+pk2 = 4.202092E-16            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.05849E-2+du0_p_lvt     lu0 = -6.062424E-10+dlu0_p_lvt wu0 = 7.096342E-11+dwu0_p_lvt 
+pu0 = 2.389839E-16+dpu0_p_lvt ua = 1.409575E-11             lua = -2.143415E-17           
+wua = -5.963288E-19           pua = 5.963288E-24            ub = 1.232665E-18             
+lub = -8.739768E-26           wub = -5.630408E-26           pub = 1.529697E-32            
+uc = 4.930144E-11             luc = -3.439635E-17           ud = 0                        
+vsat = 9.21852E4+dvsat_p_lvt  a0 = 2.493231                 la0 = 1.330351E-6             
+wa0 = 6.361928E-8             pa0 = -6.361928E-13           ags = 1.163903                
+lags = 7.377958E-7            wags = 1.230842E-9            pags = -1.230842E-14          
+b0 = 0                        b1 = 0                        keta = -8.94086E-2            
+lketa = -6.630367E-8          wketa = -3.170736E-9          pketa = 3.170736E-14          
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -4.11187E-2            lvoff = 3.645993E-9           wvoff = 1.352745E-10          
+pvoff = -1.352745E-15         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.315827            lnfactor = 5.977564E-8        wnfactor = -1.960167E-8       
+pnfactor = 4.630002E-15       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.12289E-2          
+lpdiblc2 = 2.993495E-9        wpdiblc2 = 1.285557E-10       ppdiblc2 = -1.285557E-15      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
20:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_p_lvt                   lmax = 2.0E-6-dxl_p_lvt                   wmin = 3.0E-7-dxw_p_lvt                   
+wmax = 5.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.191675+dvth0_p_lvt  lvth0 = 1.227641E-10+dlvth0_p_lvt wvth0 = -1.729598E-11+dwvth0_p_lvt 
+pvth0 = -1.045742E-15+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.04314E-2              wk2 = 1.680837E-10            k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.02494E-2+du0_p_lvt     lu0 = 6.459536E-11+dlu0_p_lvt wu0 = 1.846679E-10+dwu0_p_lvt 
+pu0 = 1.1575E-17+dpu0_p_lvt   ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.084096E-18             lub = 2.0974E-25              wub = -1.947927E-26           
+pub = -5.835266E-32           uc = 4.173424E-11             luc = -1.926196E-17           
+ud = 0                        vsat = 9.21852E4+dvsat_p_lvt  a0 = 4.348041                 
+la0 = -2.379269E-6            wa0 = -5.854504E-7            pa0 = 6.619466E-13            
+ags = 1.07296                 lags = 9.196831E-7            wags = -3.445892E-9           
+pags = -2.954952E-15          b0 = 0                        b1 = 0                        
+keta = -0.12256               wketa = 1.268295E-8           a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -3.89515E-2            lvoff = -6.885E-10            wvoff = -4.852189E-10         
+pvoff = -1.117587E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.312675            lnfactor = 6.607856E-8        wnfactor = -1.858919E-8       
+pnfactor = 2.605041E-15       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.46621E-2          
+lpdiblc2 = -3.873063E-9       wpdiblc2 = -1.082596E-9       ppdiblc2 = 1.136745E-15       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
21:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 5.0E-7-dxl_p_lvt                   lmax = 1.0E-6-dxl_p_lvt                   wmin = 3.0E-7-dxw_p_lvt                   
+wmax = 5.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.185438+dvth0_p_lvt  lvth0 = -6.113969E-9+dlvth0_p_lvt wvth0 = -2.764031E-9+dwvth0_p_lvt 
+pvth0 = 1.700993E-15+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.04314E-2              wk2 = 1.680837E-10            k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.97725E-2+du0_p_lvt     lu0 = 5.415448E-10+dlu0_p_lvt wu0 = 2.793301E-10+dwu0_p_lvt 
+pu0 = -8.308724E-17+dpu0_p_lvt ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.259104E-18             lub = 3.473224E-26            wub = -1.056997E-25           
+pub = 2.786782E-32            uc = 2.247228E-11             ud = 0                        
+vsat = 9.21852E4+dvsat_p_lvt  a0 = 2.559403                 la0 = -5.906308E-7            
+wa0 = 9.944525E-8             pa0 = -2.294911E-14           ags = 1.036174                
+lags = 9.564694E-7            wags = -3.328146E-9           pags = -3.072698E-15          
+b0 = 0                        b1 = 0                        keta = -0.12256               
+wketa = 1.268295E-8           a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.036359              lvoff = -3.280905E-9          wvoff = -1.204599E-9          
+pvoff = 6.076212E-16          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.287815            lnfactor = 9.093895E-8        wnfactor = -9.006551E-9       
+pnfactor = -6.977599E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.05922E-2          
+lpdiblc2 = 1.968623E-10       wpdiblc2 = 3.728615E-10       ppdiblc2 = -3.187118E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
22:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-7-dxl_p_lvt                   lmax = 5.0E-7-dxl_p_lvt                   wmin = 3.0E-7-dxw_p_lvt                   
+wmax = 5.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.191431+dvth0_p_lvt  lvth0 = -3.117652E-9+dlvth0_p_lvt wvth0 = 3.886607E-10+dwvth0_p_lvt 
+pvth0 = 1.246475E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -9.131319E-3             lk2 = -6.500314E-10           wk2 = -5.450729E-11           
+pk2 = 1.112955E-16            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.07214E-2+du0_p_lvt     lu0 = 6.708303E-11+dlu0_p_lvt wu0 = 1.324473E-10+dwu0_p_lvt 
+pu0 = -9.645837E-18+dpu0_p_lvt ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.228926E-18             lub = 4.98212E-26             wub = -4.621686E-26           
+pub = -1.873621E-33           uc = 2.247228E-11             ud = 0                        
+vsat = 9.21852E4+dvsat_p_lvt  a0 = 1.722426                 la0 = -1.721426E-7            
+wa0 = 6.693379E-8             pa0 = -6.693379E-15           ags = 2.949112                
+wags = -9.473542E-9           b0 = 0                        b1 = 0                        
+keta = -0.149451              lketa = 1.344529E-8           wketa = 2.016429E-8           
+pketa = -3.740672E-15         a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -3.84328E-2            lvoff = -2.244035E-9          wvoff = 1.135215E-10          
+pvoff = -5.143892E-17         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.41333             lnfactor = 2.818153E-8        wnfactor = -2.020637E-8       
+pnfactor = -1.377692E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.12807E-2          
+lpdiblc2 = -1.473864E-10      wpdiblc2 = -1.244386E-10      ppdiblc2 = -7.00617E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
23:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 6.0E-8-dxl_p_lvt                   lmax = 1.0E-7-dxl_p_lvt                   wmin = 3.0E-7-dxw_p_lvt                   
+wmax = 5.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.215242+dvth0_p_lvt  lvth0 = -7.364622E-10+dlvth0_p_lvt wvth0 = -2.489982E-9+dwvth0_p_lvt 
+pvth0 = 4.125117E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -3.986993E-3             lk2 = -1.164464E-9            wk2 = 1.218702E-9             
+pk2 = -1.602539E-17           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.16202E-2+du0_p_lvt     lu0 = -2.279875E-11+dlu0_p_lvt wu0 = 2.991554E-10+dwu0_p_lvt 
+pu0 = -2.631665E-17+dpu0_p_lvt ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.215498E-18             lub = 5.116405E-26            wub = -8.317472E-26           
+pub = 1.822165E-33            uc = 2.247228E-11             ud = 0                        
+vsat = 3.920595E4+dvsat_p_lvt lvsat = 5.297925E-3           a0 = 1E-3                     
+ags = 2.949112                wags = -9.473542E-9           b0 = 0                        
+b1 = 0                        keta = 4.38547E-2             lketa = -5.885286E-9          
+wketa = -8.576646E-9          pketa = -8.665787E-16         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -8.28665E-2            lvoff = 2.199332E-9           wvoff = 2.076483E-9           
+pvoff = -2.47735E-16          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.194643            lnfactor = 5.005021E-8        wnfactor = -9.516117E-9       
+pnfactor = -2.446716E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.33727E-2          
+lpdiblc2 = -3.565839E-10      wpdiblc2 = -3.315524E-10      ppdiblc2 = -4.935033E-17      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
24:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 4.0E-8                   lmax = 6.0E-8-dxl_p_lvt                   wmin = 3.0E-7-dxw_p_lvt                   
+wmax = 5.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.277005+dvth0_p_lvt  lvth0 = 2.969312E-9+dlvth0_p_lvt wvth0 = 4.355781E-9+dwvth0_p_lvt 
+pvth0 = 1.760766E-18+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.59612E-2              lk2 = -4.460132E-10           wk2 = 1.687223E-9             
+pk2 = -4.413669E-17           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.77547E-2+du0_p_lvt     lu0 = -3.908753E-10+dlu0_p_lvt wu0 = -3.430577E-10+dwu0_p_lvt 
+pu0 = 1.2219E-17+dpu0_p_lvt   ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.790032E-18             lub = 1.669197E-26            wub = -4.150437E-26           
+pub = -6.780558E-34           uc = 2.247228E-11             ud = 0                        
+vsat = 1.010162E5+dvsat_p_lvt lvsat = 1.589308E-3           wvsat = -1.31902E-2           
+pvsat = 7.914111E-10          a0 = 1E-3                     ags = 2.949112                
+wags = -9.473542E-9           b0 = 0                        b1 = 0                        
+keta = 0.145602               lketa = -1.199014E-8          wketa = -3.308589E-8          
+pketa = 6.039757E-16          a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.104307              lvoff = 3.485746E-9           wvoff = -2.121885E-9          
+pvoff = 4.167002E-18          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.411527            lnfactor = 3.703715E-8        wnfactor = -2.011855E-8       
+pnfactor = -1.81057E-15       eta0 = 3.11538E-2             etab = 2.57253E-2             
+letab = -2.974547E-9          wetab = 3.510486E-8           petab = -2.106292E-15         
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.63451E-2          
+lpdiblc2 = -5.349321E-10      wpdiblc2 = -2.538927E-9       ppdiblc2 = 8.309217E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
25:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_p_lvt                   lmax = 1.1E-5-dxl_p_lvt                   wmin = 1.2E-7                 
+wmax = 3.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.192429+dvth0_p_lvt  lvth0 = -3.137639E-9+dlvth0_p_lvt wvth0 = -3.081609E-11+dwvth0_p_lvt 
+pvth0 = 3.081609E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -7.891912E-3             lk2 = -5.393964E-9            wk2 = -5.297642E-11           
+pk2 = 5.297642E-16            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.92035E-2+du0_p_lvt     lu0 = 3.906592E-10+dlu0_p_lvt wu0 = 4.552849E-10+dwu0_p_lvt 
+pu0 = -3.83683E-17+dpu0_p_lvt ua = 1.195233E-11             ub = 1.200175E-18             
+lub = -5.010175E-26           wub = -4.726483E-26           pub = 4.920706E-33            
+uc = 5.737161E-11             luc = -4.00267E-17            wuc = -2.245237E-18           
+puc = 1.566444E-24            ud = 0                        vsat = 9.21852E4+dvsat_p_lvt  
+a0 = 2.712976                 la0 = -8.671005E-7            wa0 = 2.483048E-9             
+pa0 = -2.483048E-14           ags = 1.174967                lags = 6.271594E-7            
+wags = -1.847219E-9           pags = 1.847219E-14           b0 = 0                        
+b1 = 0                        keta = -0.11312               lketa = 6.167879E-8           
+wketa = 3.425986E-9           pketa = -3.899184E-15         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -4.09858E-2            lvoff = -1.46997E-9           wvoff = 9.829269E-11          
+pvoff = 7.058857E-17          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.298047            lnfactor = 8.664679E-8        wnfactor = -1.465514E-8       
+pnfactor = -2.845934E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.15757E-2          
+lpdiblc2 = -4.747329E-10      wpdiblc2 = 3.206467E-11       ppdiblc2 = -3.206467E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
26:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_p_lvt                   lmax = 2.0E-6-dxl_p_lvt                   wmin = 1.2E-7                 
+wmax = 3.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.19186+dvth0_p_lvt   lvth0 = -4.275484E-9+dlvth0_p_lvt wvth0 = 3.430756E-11+dwvth0_p_lvt 
+pvth0 = 1.779136E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.16802E-2              lk2 = 2.18253E-9              wk2 = 5.155112E-10            
+pk2 = -6.072111E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.93673E-2+du0_p_lvt     lu0 = 6.298573E-11+dlu0_p_lvt wu0 = 4.300893E-10+dwu0_p_lvt 
+pu0 = 1.202283E-17+dpu0_p_lvt ua = 1.195233E-11             ub = 1.175124E-18             
+wub = -4.480448E-26           uc = 4.635864E-11             luc = -1.800077E-17           
+wuc = -1.286575E-18           puc = -3.508814E-25           ud = 0                        
+vsat = 9.21852E4+dvsat_p_lvt  a0 = 2.279426                 wa0 = -9.932191E-9            
+ags = 1.041984                lags = 8.931262E-7            wags = 5.172093E-9            
+pags = 4.433569E-15           b0 = 0                        b1 = 0                        
+keta = -8.22802E-2            wketa = 1.476394E-9           a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -4.13972E-2            lvoff = -6.471446E-10         wvoff = 1.952191E-10          
+pvoff = -1.232643E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.302568            lnfactor = 7.76038E-8         wnfactor = -1.577738E-8       
+pnfactor = -6.01445E-16       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.14534E-2          
+lpdiblc2 = -2.302554E-10      wpdiblc2 = -1.898908E-10      ppdiblc2 = 1.232643E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
27:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 5.0E-7-dxl_p_lvt                   lmax = 1.0E-6-dxl_p_lvt                   wmin = 1.2E-7                 
+wmax = 3.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.195659+dvth0_p_lvt  lvth0 = -4.763392E-10+dlvth0_p_lvt wvth0 = 7.969677E-11+dwvth0_p_lvt 
+pvth0 = 1.325243E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -1.11124E-2              lk2 = 1.614806E-9             wk2 = 3.575622E-10            
+pk2 = -4.492621E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.93511E-2+du0_p_lvt     lu0 = 7.920957E-11+dlu0_p_lvt wu0 = 3.965711E-10+dwu0_p_lvt 
+pu0 = 4.554101E-17+dpu0_p_lvt ua = 1.195233E-11             ub = 1.06643E-18              
+lub = 1.086942E-25            wub = -5.209502E-26           pub = 7.290539E-33            
+uc = 2.835787E-11             wuc = -1.637456E-18           ud = 0                        
+vsat = 9.21852E4+dvsat_p_lvt  a0 = 2.795285                 la0 = -5.158595E-7            
+wa0 = 3.381936E-8             pa0 = -4.375155E-14           ags = 1.265817                
+lags = 6.692929E-7            wags = -6.721823E-8           pags = 7.682389E-14           
+b0 = 0                        b1 = 0                        keta = -8.22802E-2            
+wketa = 1.476394E-9           a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -4.11305E-2            lvoff = -9.13785E-10          wvoff = 1.229E-10             
+pvoff = -5.094521E-17         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.312731            lnfactor = 6.74408E-8         wnfactor = -1.593875E-8       
+pnfactor = -4.40078E-16       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.09634E-2          
+lpdiblc2 = 2.597392E-10       wpdiblc2 = 2.695785E-10       ppdiblc2 = -3.36205E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
28:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-7-dxl_p_lvt                   lmax = 5.0E-7-dxl_p_lvt                   wmin = 1.2E-7                 
+wmax = 3.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.190412+dvth0_p_lvt  lvth0 = -3.100063E-9+dlvth0_p_lvt wvth0 = 1.052377E-10+dwvth0_p_lvt 
+pvth0 = 1.197539E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -7.809711E-3             lk2 = -3.655552E-11           wk2 = -4.221974E-10           
+pk2 = -5.938225E-17           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96163E-2+du0_p_lvt     lu0 = -5.338175E-11+dlu0_p_lvt wu0 = 4.399148E-10+dwu0_p_lvt 
+pu0 = 2.386918E-17+dpu0_p_lvt ua = 1.195233E-11             ub = 1.209676E-18             
+lub = 3.707127E-26            wub = -4.086112E-26           pub = 1.673592E-33            
+uc = 2.835787E-11             wuc = -1.637456E-18           ud = 0                        
+vsat = 9.70031E4+dvsat_p_lvt  lvsat = -2.408943E-3          wvsat = -1.340405E-3          
+pvsat = 6.702024E-10          a0 = 2.204208                 la0 = -2.203208E-7            
+wa0 = -6.710468E-8            pa0 = 6.710468E-15            ags = 2.604403                
+wags = 8.642956E-8            b0 = 0                        b1 = 0                        
+keta = -9.49368E-2            lketa = 6.328286E-9           wketa = 4.997633E-9           
+pketa = -1.760619E-15         a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -3.85647E-2            lvoff = -2.196689E-9          wvoff = 1.502322E-10          
+pvoff = -6.461131E-17         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.393899            lnfactor = 2.68568E-8         wnfactor = -1.480064E-8       
+pnfactor = -1.009132E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.18902E-2          
+lpdiblc2 = -2.036576E-10      wpdiblc2 = -2.94019E-10       ppdiblc2 = -5.440625E-17      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
29:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 6.0E-8-dxl_p_lvt                   lmax = 1.0E-7-dxl_p_lvt                   wmin = 1.2E-7                 
+wmax = 3.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.238011+dvth0_p_lvt  lvth0 = 1.659806E-9+dlvth0_p_lvt wvth0 = 3.84442E-9+dwvth0_p_lvt 
+pvth0 = -2.541644E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -5.319755E-3             lk2 = -2.855511E-10           wk2 = 1.589495E-9             
+pk2 = -2.605515E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.12229E-2+du0_p_lvt     lu0 = -2.14041E-10+dlu0_p_lvt wu0 = 4.097097E-10+dwu0_p_lvt 
+pu0 = 2.688969E-17+dpu0_p_lvt ua = 1.195233E-11             ub = 1.016076E-18             
+lub = 5.64312E-26             wub = -2.769288E-26           pub = 3.567683E-34            
+uc = 2.835787E-11             wuc = -1.637456E-18           ud = 0                        
+vsat = -8.97292E3+dvsat_p_lvt lvsat = 8.188657E-3           wvsat = 0.013404              
+pvsat = -8.042429E-10         a0 = 1E-3                     ags = 2.604403                
+wags = 8.642956E-8            b0 = 0                        b1 = 0                        
+keta = 0.152975               lketa = -1.84629E-8           wketa = -3.893548E-8          
+pketa = 2.632692E-15          a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.086049              lvoff = 2.551746E-9           wvoff = 2.961934E-9           
+pvoff = -3.457815E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.18549             lnfactor = 4.769772E-8        wnfactor = -6.969748E-9       
+pnfactor = -1.792221E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.74584E-2          
+lpdiblc2 = -7.60473E-10       wpdiblc2 = -1.468255E-9       ppdiblc2 = 6.301736E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
30:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 4.0E-8                   lmax = 6.0E-8-dxl_p_lvt                   wmin = 1.2E-7                 
+wmax = 3.0E-7-dxw_p_lvt                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_lvt              toxm = tox_p_lvt              
+dtox = 4.05E-10               xj = 1.7E-7                   ndep = 1.19E18                
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_lvt              
+xw = 0+dxw_p_lvt              
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.283135+dvth0_p_lvt  lvth0 = 4.367271E-9+dlvth0_p_lvt wvth0 = 6.061205E-9+dwvth0_p_lvt 
+pvth0 = -3.871715E-16+dpvth0_p_lvt phin = 0                      k1 = 0.25                     
+k2 = -7.128531E-3             lk2 = -1.770246E-10           wk2 = -7.701441E-10           
+pk2 = -1.189732E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 2.47139E-2+du0_p_lvt     lu0 = -4.235042E-10+dlu0_p_lvt wu0 = 5.029246E-10+dwu0_p_lvt 
+pu0 = 2.12968E-17+dpu0_p_lvt  ua = 1.195233E-11             ub = 1.495572E-18             
+lub = 2.766144E-26            wub = 4.041856E-26            pub = -3.729918E-33           
+uc = 2.835787E-11             wuc = -1.637456E-18           ud = 0                        
+vsat = 5.360565E4+dvsat_p_lvt lvsat = 4.433941E-3           wvsat = 0                     
+pvsat = -5.901348E-15         a0 = 1E-3                     ags = 2.604403                
+wags = 8.642956E-8            b0 = 0                        b1 = 0                        
+keta = 0.076145               lketa = -1.38531E-8           wketa = -1.376189E-8          
+pketa = 1.122276E-15          a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.131916              lvoff = 5.303768E-9           wvoff = 5.559449E-9           
+pvoff = -5.016324E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.511088            lnfactor = 2.816183E-8        wnfactor = -4.781791E-8       
+pnfactor = 6.586688E-16       eta0 = 3.11538E-2             etab = 0.247803               
+letab = -1.629918E-8          wetab = -2.66802E-8           petab = 1.600812E-15          
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.06974E-2          
+lpdiblc2 = -3.548114E-10      wpdiblc2 = -9.67633E-10       ppdiblc2 = 3.298003E-17       
+pdiblcb = 0                   drout = 0.962144              ldrout = 1.023288E-8          
+wdrout = 4.744888E-8          pdrout = -2.846933E-15        pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 8.7E-8                bgidl = 3.44E9                
+cgidl = 0.51                  egidl = 0.15                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 3.11E-3             cigbacc = 0.2                 
+nigbacc = 5.24                aigbinv = 0.354               bigbinv = 0.0289              
+cigbinv = 6.24E-3             eigbinv = 1.07                nigbinv = 1.07                
+aigc = 6.82E-3                bigc = 6.741E-4               cigc = 0                      
+aigsd = 5.78E-3               bigsd = 2.61E-4               cigsd = 0.0331                
+dlcig = 2.61E-9               nigc = 2.3                    poxedge = 1                   
+pigcd = 2.18                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 1.51E42                noib = 3.47E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.22                     
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.7E-11+dcgso_p_lvt    cgdo = 3.7E-11+dcgdo_p_lvt    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0               dwc = 0                       noff = 2.46                   
+voffcv = -0.081               acde = 1.2                    moin = 8.5                    
+cgsl = 0.4E-10+dcgsl_p_lvt   cgdl = 0.4E-10+dcgdl_p_lvt   
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.81E-7                 jsws = 7.98E-13               
+jswgs = 4.47E-12              cjs = 8.28E-4+dcj_p_lvt       mjs = 0.31                    
+mjsws = 0.012                 cjsws = 7.1E-11+dcjsw_p_lvt   cjswgs = 2.03E-10+dcjswg_p_lvt 
+mjswgs = 0.81                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.54                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.0668                 kt1 = -0.1832                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 5.600014E4               
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 9E-8                    kvsat = -0.376                kvth0 = 2.05E-10              
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -230                    wec = -3E3                    kvth0we = -3.21E-3            
+k2we = 3E-4                   ku0we = -3.2E-3               scref = 1E-6                  
}
endsection  mos_lvt




section  mos_na
//  ***********************
//     Mismatch   model   * 
//  ***********************
inline subckt gpdk045_nmos1v_nat ( d g s b ) 
parameters
+l=1e-6 w=1e-6 multi=1 nf=1 factor=1
+dmcg=4E-8 	
+xw=0+dxw_n_na
+ad=2*dmcg/factor*(w/nf+xw/factor) 
+as=2*dmcg/factor*(w/nf+xw/factor)
+pd=4*dmcg/factor+2*(w/nf+xw/factor) 
+ps=4*dmcg/factor+2*(w/nf+xw/factor)
+nrd=dmcg/factor/(w/nf+xw/factor)
+nrs=dmcg/factor/(w/nf+xw/factor)
+sa=6.1E-7/factor 
+sb=6.1E-7/factor 
+sd=2*dmcg/factor
+sca=1E-6/factor
+scb=1E-6/factor 
+scc=1E-6/factor
+misa1=rn1_na  misa2=rn2_na
+fac1=0.513*misa1+0.421*misa2
+fac2=0.513*misa1-0.421*misa2
+lef=l*factor
+wef=w/nf*factor
+geo_fac =1/sqrt(multi*nf*lef*wef*1e12)
+vthmis_n= 0.00198*geo_fac*fac1 
+dlmis_n= 0.00105*geo_fac*lef*fac2 
+dwmis_n= -0.00105*geo_fac*wef*fac2 
+toxmis_n= 0.00105*geo_fac*tox_n_na*fac2 
gpdk045_nmos1v_nat ( d n1 s b ) nch_na w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
//********include rg model ***************//
include "gpdk045_mos.scs"   section = res_rg
xrg ( g n1 ) ressnpoly_rg  ll=(w/3/nf/nf)*factor+5e-9 ww=l*factor  mf =multi
model nch_na bsim4 {
1:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_na+dlmis_n)        lmax = 1.1E-5-(dxl_n_na+dlmis_n)        wmin = 2.0E-6-(dxw_n_na+dwmis_n)        
+wmax = 1.1E-5-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+(dxl_n_na+dlmis_n)             
+xw = 0.0+(dxw_n_na+dwmis_n)             
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0.0+dlvth0_n_na       wvth0 = 0.0+dwvth0_n_na       
+pvth0 = 0.0+dpvth0_n_na       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 194528.3+dvsat_n_na    
+wvsat = -1.39998E-2           a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124788              wvoff = -2.150079E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0.0+dcgsl_n_na         cgdl = 0.0+dcgdl_n_na         
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
2:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n_na+dlmis_n)        lmax = 2.0E-6-(dxl_n_na+dlmis_n)        wmin = 2.0E-6-(dxw_n_na+dwmis_n)        
+wmax = 1.1E-5-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na+dlmis_n)               
+xw = 0+(dxw_n_na+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945283E5+dvsat_n_na  
+wvsat = -1.39998E-2           a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124788              wvoff = -2.150079E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
3:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 3E-7                   lmax = 1.0E-6-(dxl_n_na+dlmis_n)        wmin = 2.0E-6-(dxw_n_na+dwmis_n)        
+wmax = 1.1E-5-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na+dlmis_n)               
+xw = 0+(dxw_n_na+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945283E5+dvsat_n_na  
+wvsat = -1.39998E-2           a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124788              wvoff = -2.150079E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
4:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_na+dlmis_n)        lmax = 1.1E-5-(dxl_n_na+dlmis_n)        wmin = 1.0E-6-(dxw_n_na+dwmis_n)        
+wmax = 2.0E-6-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na+dlmis_n)               
+xw = 0+(dxw_n_na+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124789              wvoff = -2.149841E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
5:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n_na+dlmis_n)        lmax = 2.0E-6-(dxl_n_na+dlmis_n)        wmin = 1.0E-6-(dxw_n_na+dwmis_n)        
+wmax = 2.0E-6-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na+dlmis_n)               
+xw = 0+(dxw_n_na+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124789              wvoff = -2.149841E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
6:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 3E-7                   lmax = 1.0E-6-(dxl_n_na+dlmis_n)        wmin = 1.0E-6-(dxw_n_na+dwmis_n)        
+wmax = 2.0E-6-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na+dlmis_n)               
+xw = 0+(dxw_n_na+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124789              wvoff = -2.149841E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
7:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_na+dlmis_n)        lmax = 1.1E-5-(dxl_n_na+dlmis_n)        wmin = 5E-7                   
+wmax = 1.0E-6-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na+dlmis_n)               
+xw = 0+(dxw_n_na+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124787              wvoff = -2.150056E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
8:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n_na+dlmis_n)        lmax = 2.0E-6-(dxl_n_na+dlmis_n)        wmin = 5E-7                   
+wmax = 1.0E-6-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na+dlmis_n)               
+xw = 0+(dxw_n_na+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124787              wvoff = -2.150056E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
9:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 3E-7                   lmax = 1.0E-6-(dxl_n_na+dlmis_n)        wmin = 5E-7                   
+wmax = 1.0E-6-(dxw_n_na+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na+toxmis_n               toxm = tox_n_na+toxmis_n               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na+dlmis_n)               
+xw = 0+(dxw_n_na+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.040625+dvth0_n_na+vthmis_n    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0318438+du0_n_na       lu0 = 0.0+dlu0_n_na           wu0 = 0.0+dwu0_n_na           
+pu0 = 0.0+dpu0_n_na           ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.124787              wvoff = -2.150056E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
}

ends gpdk045_nmos1v_nat

model nch_na bsim4 {
1:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_na                   lmax = 1.1E-5-dxl_n_na                   wmin = 2.0E-6-dxw_n_na                   
+wmax = 1.1E-5-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+dxl_n_na             
+xw = 0.0+dxw_n_na             
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0.0+dlvth0_n_na       wvth0 = 0.0+dwvth0_n_na       
+pvth0 = 0.0+dpvth0_n_na       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 194528.3+dvsat_n_na    
+wvsat = -1.39998E-2           a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124788              wvoff = -2.150079E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0.0+dcgsl_n_na         cgdl = 0.0+dcgdl_n_na         
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
2:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n_na                   lmax = 2.0E-6-dxl_n_na                   wmin = 2.0E-6-dxw_n_na                   
+wmax = 1.1E-5-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na               
+xw = 0+dxw_n_na               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945283E5+dvsat_n_na  
+wvsat = -1.39998E-2           a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124788              wvoff = -2.150079E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
3:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 3.0E-7                   lmax = 1.0E-6-dxl_n_na                   wmin = 2.0E-6-dxw_n_na                   
+wmax = 1.1E-5-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na               
+xw = 0+dxw_n_na               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945283E5+dvsat_n_na  
+wvsat = -1.39998E-2           a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124788              wvoff = -2.150079E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
4:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_na                   lmax = 1.1E-5-dxl_n_na                   wmin = 1.0E-6-dxw_n_na                   
+wmax = 2.0E-6-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na               
+xw = 0+dxw_n_na               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124789              wvoff = -2.149841E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
5:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n_na                   lmax = 2.0E-6-dxl_n_na                   wmin = 1.0E-6-dxw_n_na                   
+wmax = 2.0E-6-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na               
+xw = 0+dxw_n_na               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124789              wvoff = -2.149841E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
6:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 3.0E-7                   lmax = 1.0E-6-dxl_n_na                   wmin = 1.0E-6-dxw_n_na                   
+wmax = 2.0E-6-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na               
+xw = 0+dxw_n_na               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124789              wvoff = -2.149841E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
7:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_na                   lmax = 1.1E-5-dxl_n_na                   wmin = 5.0E-7                   
+wmax = 1.0E-6-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na               
+xw = 0+dxw_n_na               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124787              wvoff = -2.150056E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
8:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n_na                   lmax = 2.0E-6-dxl_n_na                   wmin = 5.0E-7                   
+wmax = 1.0E-6-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na               
+xw = 0+dxw_n_na               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124787              wvoff = -2.150056E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
9:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 3.0E-7                   lmax = 1.0E-6-dxl_n_na                   wmin = 5.0E-7                   
+wmax = 1.0E-6-dxw_n_na                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na               toxm = tox_n_na               
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na               
+xw = 0+dxw_n_na               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.040625+dvth0_n_na    lvth0 = 0+dlvth0_n_na         wvth0 = 0+dwvth0_n_na         
+pvth0 = 0+dpvth0_n_na         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.7722                  k3b = 2.454986                
+w0 = -4.095012E-8             lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0318438+du0_n_na               lu0 = 0.0+dlu0_n_na                       wu0 = 0.0+dwu0_n_na                       
+pu0 = 0.0+dpu0_n_na                       ua = -1.4E-10                 ub = 1.304949E-18             
+uc = 0                        ud = 0                        vsat = 1.945284E5+dvsat_n_na  
+wvsat = -0.014                a0 = 0.87                     ags = 1.72308                 
+b0 = 0                        b1 = 0                        keta = -6.17037E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.124787              wvoff = -2.150056E-8          voffl = -3.095178E-9          
+minv = -0.15                  nfactor = 0.820003            eta0 = 2.963491E-3            
+etab = -1.59363E-2            dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.542346E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0121                 bigc = 1.56E-3                cigc = 0                      
+aigsd = 9.87E-3               bigsd = 1.235E-3              cigsd = 0.02                  
+dlcig = 2.48E-9               nigc = 2.1                    poxedge = 1                   
+pigcd = 2.81                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7E42                   noib = 2.31E20                noic = 3E8                    
+em = 1E6                      ef = 0.9                      lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 1.16E-10+dcgso_n_na    cgdo = 1.16E-10+dcgdo_n_na    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 3                      
+voffcv = -0.064               acde = 1                      moin = 7                      
+cgsl = 0+dcgsl_n_na           cgdl = 0+dcgdl_n_na           
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 6.3E-7                  jsws = 1E-12                  
+jswgs = 5E-13                 cjs = 1.31E-4+dcj_n_na        mjs = 0.33                    
+mjsws = 0.0124                cjsws = 9.21E-11+dcjsw_n_na   cjswgs = 2.04E-10+dcjswg_n_na 
+mjswgs = 0.55                 pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.7                    kt1 = -0.144784               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 1E-18                   uc1 = 7.839E-11               at = 8.4E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 3.7E-7                 
+ku0 = -6.471E-8               kvsat = 0.165                 kvth0 = 3.461E-9              
+tku0 = 0.089                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.1E-7                 
+wku0 = 8.96E-7                pku0 = 0                      lkvth0 = -2.421E-11           
+wkvth0 = 2E-6                 pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
}
endsection  mos_na


section  mos18

//  ***********************
//     Mismatch   model   * 
//  ***********************
inline subckt gpdk045_nmos2v ( d g s b ) 
parameters
+l=1e-6 w=1e-6 multi=1 nf=1 factor=1
+dmcg=4E-8 	
+xw=0+dxw_n_18
+ad=2*dmcg/factor*(w/nf+xw/factor) 
+as=2*dmcg/factor*(w/nf+xw/factor)
+pd=4*dmcg/factor+2*(w/nf+xw/factor) 
+ps=4*dmcg/factor+2*(w/nf+xw/factor)
+nrd=dmcg/factor/(w/nf+xw/factor)
+nrs=dmcg/factor/(w/nf+xw/factor)
+sa=6.1E-7/factor 
+sb=6.1E-7/factor 
+sd=2*dmcg/factor
+sca=1E-6/factor
+scb=1E-6/factor 
+scc=1E-6/factor
+misa1=rn1_18  misa2=rn2_18
+fac1=0.437*misa1+0.725*misa2
+fac2=0.437*misa1-0.725*misa2
+lef=l*factor
+wef=w/nf*factor
+geo_fac =1/sqrt(multi*nf*lef*wef*1e12)
+vthmis_n= 0.00291*geo_fac*fac1 
+dlmis_n= 0.00149*geo_fac*lef*fac2 
+dwmis_n= -0.00149*geo_fac*wef*fac2 
+toxmis_n= 0.00149*geo_fac*tox_n_18*fac2 
gpdk045_nmos2v ( d n1 s b ) nch18 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
//********include rg model ***************//
include "gpdk045_mos.scs"   section = res_rg
xrg ( g n1 ) ressnpoly_rg  ll=(w/3/nf/nf)*factor+5e-9 ww=l*factor  mf =multi
model nch18 bsim4 {
1:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_18+dlmis_n)        lmax = 1.1E-5-(dxl_n_18+dlmis_n)        wmin = 2.0E-6-(dxw_n_18+dwmis_n)        
+wmax = 1.1E-5-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+(dxl_n_18+dlmis_n)             
+xw = 0.0+(dxw_n_18+dwmis_n)             
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0.0+dlvth0_n_18       wvth0 = 0.0+dwvth0_n_18       
+pvth0 = 0.0+dpvth0_n_18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0298009+du0_n_18       lu0 = 0.0+dlu0_n_18           wu0 = 0.0+dwu0_n_18           
+pu0 = 0.0+dpu0_n_18           ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 115107.0+dvsat_n_18    
+wvsat = -2.499988E-3          a0 = 1.08155                  ags = 1.051675                
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
2:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n_18+dlmis_n)        lmax = 2.0E-6-(dxl_n_18+dlmis_n)        wmin = 2.0E-6-(dxw_n_18+dwmis_n)        
+wmax = 1.1E-5-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.499988E-3          a0 = 1.08155                  ags = 1.051675                
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
3:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 1.5E-7                 lmax = 1.0E-6-(dxl_n_18+dlmis_n)        wmin = 2.0E-6-(dxw_n_18+dwmis_n)        
+wmax = 1.1E-5-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.499988E-3          a0 = 1.08155                  ags = 1.051675                
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
4:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_18+dlmis_n)        lmax = 1.1E-5-(dxl_n_18+dlmis_n)        wmin = 1.0E-6-(dxw_n_18+dwmis_n)        
+wmax = 2.0E-6-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.49993E-3           a0 = 1.08155                  ags = 1.051675                
+wags = -5.000059E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
5:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n_18+dlmis_n)        lmax = 2.0E-6-(dxl_n_18+dlmis_n)        wmin = 1.0E-6-(dxw_n_18+dwmis_n)        
+wmax = 2.0E-6-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.49993E-3           a0 = 1.08155                  ags = 1.051675                
+wags = -5.000059E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
6:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 1.5E-7                 lmax = 1.0E-6-(dxl_n_18+dlmis_n)        wmin = 1.0E-6-(dxw_n_18+dwmis_n)        
+wmax = 2.0E-6-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.49993E-3           a0 = 1.08155                  ags = 1.051675                
+wags = -5.000059E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
7:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_18+dlmis_n)        lmax = 1.1E-5-(dxl_n_18+dlmis_n)        wmin = 5.0E-7-(dxw_n_18+dwmis_n)        
+wmax = 1.0E-6-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500017E-3          a0 = 1.08155                  ags = 1.051674                
+wags = -4.999936E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
8:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n_18+dlmis_n)        lmax = 2.0E-6-(dxl_n_18+dlmis_n)        wmin = 5.0E-7-(dxw_n_18+dwmis_n)        
+wmax = 1.0E-6-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500017E-3          a0 = 1.08155                  ags = 1.051674                
+wags = -4.999936E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
9:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                
//*** geometry range parameter ***
+lmin = 1.5E-7                 lmax = 1.0E-6-(dxl_n_18+dlmis_n)        wmin = 5.0E-7-(dxw_n_18+dwmis_n)        
+wmax = 1.0E-6-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
