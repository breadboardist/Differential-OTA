+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500017E-3          a0 = 1.08155                  ags = 1.051674                
+wags = -4.999936E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
10:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_18+dlmis_n)        lmax = 1.1E-5-(dxl_n_18+dlmis_n)        wmin = 3.2E-7                 
+wmax = 5.0E-7-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500026E-3          a0 = 1.08155                  ags = 1.051677                
+wags = -5.000053E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
11:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n_18+dlmis_n)        lmax = 2.0E-6-(dxl_n_18+dlmis_n)        wmin = 3.2E-7                 
+wmax = 5.0E-7-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500026E-3          a0 = 1.08155                  ags = 1.051677                
+wags = -5.000053E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
12:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                
//*** geometry range parameter ***
+lmin = 1.5E-7                 lmax = 1.0E-6-(dxl_n_18+dlmis_n)        wmin = 3.2E-7                 
+wmax = 5.0E-7-(dxw_n_18+dwmis_n)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_18+toxmis_n               toxm = tox_n_18+toxmis_n               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_18+dlmis_n)               
+xw = 0+(dxw_n_18+dwmis_n)               
//*** flicker noise model parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.4207+dvth0_n_18+vthmis_n      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500026E-3          a0 = 1.08155                  ags = 1.051677                
+wags = -5.000053E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
}

ends gpdk045_nmos2v



inline subckt gpdk045_pmos2v ( d g s b ) 
parameters
+l=1e-6 w=1e-6 multi=1 nf=1 factor=1
+dmcg=8.5E-8 	
+xw=0+dxw_p_18
+ad=2*dmcg/factor*(w/nf+xw/factor) 
+as=2*dmcg/factor*(w/nf+xw/factor)
+pd=4*dmcg/factor+2*(w/nf+xw/factor) 
+ps=4*dmcg/factor+2*(w/nf+xw/factor)
+nrd=dmcg/factor/(w/nf+xw/factor)
+nrs=dmcg/factor/(w/nf+xw/factor)
+sa=6.1E-7/factor 
+sb=6.1E-7/factor 
+sd=2*dmcg/factor
+sca=1E-6/factor
+scb=1E-6/factor 
+scc=1E-6/factor
+misa1=rp1_18  misa2=rp2_18
+fac1=0.821*misa1+0.341*misa2
+fac2=0.821*misa1-0.341*misa2
+lef=l*factor
+wef=w/nf*factor
+geo_fac =1/sqrt(multi*nf*lef*wef*1e12)
+vthmis_p= 0.00229*geo_fac*fac1 
+dlmis_p= 0.00163*geo_fac*lef*fac2 
+dwmis_p= -0.00163*geo_fac*wef*fac2 
+toxmis_p= 0.00163*geo_fac*tox_p_18*fac2 
gpdk045_pmos2v ( d n1 s b ) pch18 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
//********include rg model ***************//
include "gpdk045_mos.scs"   section = res_rg
xrg ( g n1 ) ressppoly_rg  ll=(w/3/nf/nf)*factor+5e-9 ww=l*factor  mf =multi
model pch18 bsim4 {
1:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p_18+dlmis_p)        lmax = 1.1E-5-(dxl_p_18+dlmis_p)        wmin = 2.0E-6-(dxw_p_18+dwmis_p)        
+wmax = 1.1E-5-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+(dxl_p_18+dlmis_p)             
+xw = 0.0+(dxw_p_18+dwmis_p)             
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0.0+dlvth0_p_18       wvth0 = 0.0+dwvth0_p_18       
+pvth0 = 0.0+dpvth0_p_18       phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 0.0196662+du0_p_18       lu0 = 0.0+dlu0_p_18           wu0 = 0.0+dwu0_p_18           
+pu0 = 0.0+dpu0_p_18           ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000007E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 65731.5+dvsat_p_18     a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
2:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p_18+dlmis_p)        lmax = 2.0E-6-(dxl_p_18+dlmis_p)        wmin = 2.0E-6-(dxw_p_18+dwmis_p)        
+wmax = 1.1E-5-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000007E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
3:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.5E-7                 lmax = 1.0E-6-(dxl_p_18+dlmis_p)        wmin = 2.0E-6-(dxw_p_18+dwmis_p)        
+wmax = 1.1E-5-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000007E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
4:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p_18+dlmis_p)        lmax = 1.1E-5-(dxl_p_18+dlmis_p)        wmin = 1.0E-6-(dxw_p_18+dwmis_p)        
+wmax = 2.0E-6-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.56985E-18              
+wub = -2.999987E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
5:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p_18+dlmis_p)        lmax = 2.0E-6-(dxl_p_18+dlmis_p)        wmin = 1.0E-6-(dxw_p_18+dwmis_p)        
+wmax = 2.0E-6-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.56985E-18              
+wub = -2.999987E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
6:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.5E-7                 lmax = 1.0E-6-(dxl_p_18+dlmis_p)        wmin = 1.0E-6-(dxw_p_18+dwmis_p)        
+wmax = 2.0E-6-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.56985E-18              
+wub = -2.999987E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
7:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p_18+dlmis_p)        lmax = 1.1E-5-(dxl_p_18+dlmis_p)        wmin = 5.0E-7-(dxw_p_18+dwmis_p)        
+wmax = 1.0E-6-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000001E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
8:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p_18+dlmis_p)        lmax = 2.0E-6-(dxl_p_18+dlmis_p)        wmin = 5.0E-7-(dxw_p_18+dwmis_p)        
+wmax = 1.0E-6-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000001E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
9:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.5E-7                 lmax = 1.0E-6-(dxl_p_18+dlmis_p)        wmin = 5.0E-7-(dxw_p_18+dwmis_p)        
+wmax = 1.0E-6-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000001E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
10:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p_18+dlmis_p)        lmax = 1.1E-5-(dxl_p_18+dlmis_p)        wmin = 3.2E-7                 
+wmax = 5.0E-7-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -2.999999E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
11:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p_18+dlmis_p)        lmax = 2.0E-6-(dxl_p_18+dlmis_p)        wmin = 3.2E-7                 
+wmax = 5.0E-7-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -2.999999E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
12:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.5E-7                 lmax = 1.0E-6-(dxl_p_18+dlmis_p)        wmin = 3.2E-7                 
+wmax = 5.0E-7-(dxw_p_18+dwmis_p)        
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p_18+toxmis_p               toxm = tox_p_18+toxmis_p               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p_18+dlmis_p)               
+xw = 0+(dxw_p_18+dwmis_p)               
//*** flicker noise model parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.35906+dvth0_p_18+vthmis_p    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -2.999999E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18       cgdl = 1E-10+dcgdl_p_18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
}

ends gpdk045_pmos2v


model nch18 bsim4 {
1:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_18                   lmax = 1.1E-5-dxl_n_18                   wmin = 2.0E-6-dxw_n_18                   
+wmax = 1.1E-5-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+dxl_n_18             
+xw = 0.0+dxw_n_18             
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0.0+dlvth0_n_18       wvth0 = 0.0+dwvth0_n_18       
+pvth0 = 0.0+dpvth0_n_18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0298009+du0_n_18       lu0 = 0.0+dlu0_n_18           wu0 = 0.0+dwu0_n_18           
+pu0 = 0.0+dpu0_n_18           ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 115107.0+dvsat_n_18    
+wvsat = -2.499988E-3          a0 = 1.08155                  ags = 1.051675                
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
2:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n_18                   lmax = 2.0E-6-dxl_n_18                   wmin = 2.0E-6-dxw_n_18                   
+wmax = 1.1E-5-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.499988E-3          a0 = 1.08155                  ags = 1.051675                
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
3:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.5E-7                lmax = 1.0E-6-dxl_n_18                   wmin = 2.0E-6-dxw_n_18                   
+wmax = 1.1E-5-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.499988E-3          a0 = 1.08155                  ags = 1.051675                
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
4:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_18                   lmax = 1.1E-5-dxl_n_18                   wmin = 1.0E-6-dxw_n_18                   
+wmax = 2.0E-6-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.49993E-3           a0 = 1.08155                  ags = 1.051675                
+wags = -5.000059E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
5:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n_18                   lmax = 2.0E-6-dxl_n_18                   wmin = 1.0E-6-dxw_n_18                   
+wmax = 2.0E-6-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.49993E-3           a0 = 1.08155                  ags = 1.051675                
+wags = -5.000059E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
6:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.5E-7                lmax = 1.0E-6-dxl_n_18                   wmin = 1.0E-6-dxw_n_18                   
+wmax = 2.0E-6-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.15107E5+dvsat_n_18   
+wvsat = -2.49993E-3           a0 = 1.08155                  ags = 1.051675                
+wags = -5.000059E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
7:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_18                   lmax = 1.1E-5-dxl_n_18                   wmin = 5.0E-7-dxw_n_18                   
+wmax = 1.0E-6-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500017E-3          a0 = 1.08155                  ags = 1.051674                
+wags = -4.999936E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
8:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n_18                   lmax = 2.0E-6-dxl_n_18                   wmin = 5.0E-7-dxw_n_18                   
+wmax = 1.0E-6-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500017E-3          a0 = 1.08155                  ags = 1.051674                
+wags = -4.999936E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
9:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.5E-7                lmax = 1.0E-6-dxl_n_18                   wmin = 5.0E-7-dxw_n_18                   
+wmax = 1.0E-6-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500017E-3          a0 = 1.08155                  ags = 1.051674                
+wags = -4.999936E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
10:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_18                   lmax = 1.1E-5-dxl_n_18                   wmin = 3.2E-7                 
+wmax = 5.0E-7-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500026E-3          a0 = 1.08155                  ags = 1.051677                
+wags = -5.000053E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
11:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n_18                   lmax = 2.0E-6-dxl_n_18                   wmin = 3.2E-7                 
+wmax = 5.0E-7-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500026E-3          a0 = 1.08155                  ags = 1.051677                
+wags = -5.000053E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
12:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.5E-7                lmax = 1.0E-6-dxl_n_18                   wmin = 3.2E-7                 
+wmax = 5.0E-7-dxw_n_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_18               toxm = tox_n_18               
+dtox = 3.2E-10                xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_18               
+xw = 0+dxw_n_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.4207+dvth0_n_18      lvth0 = 0+dlvth0_n_18         wvth0 = 0+dwvth0_n_18         
+pvth0 = 0+dpvth0_n_18         phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.98009E-2+du0_n_18      lu0 = 0+dlu0_n_18             wu0 = 0+dwu0_n_18             
+pu0 = 0+dpu0_n_18             ua = -9.49994E-10             ub = 2.091579E-18             
+uc = 7.758295E-11             ud = 0                        vsat = 1.151071E5+dvsat_n_18  
+wvsat = -2.500026E-3          a0 = 1.08155                  ags = 1.051677                
+wags = -5.000053E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.1505E-7             bgidl = 2.692E9               
+cgidl = 0.24                  egidl = 0.24                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.0211              bigbacc = 2.44E-3             cigbacc = 0.312               
+nigbacc = 6                   aigbinv = 0.017               bigbinv = 4.3E-3              
+cigbinv = 5.7E-3              eigbinv = 1.04                nigbinv = 6                   
+aigc = 0.012                  bigc = 1.41E-3                cigc = 5.72E-4                
+aigsd = 0.0116                bigsd = 1.3E-3                cigsd = 0.073                 
+dlcig = 2.43E-9               nigc = 2.97                   poxedge = 1                   
+pigcd = 2.4                   ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E42                 noib = 1.81E21                noic = 3E8                    
+em = 1E6                      ef = 0.86                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 3.13E-11+dcgso_n_18    cgdo = 3.13E-11+dcgdo_n_18    
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.6                    
+voffcv = -0.097               acde = 1                      moin = 5.67                   
+cgsl = 2.71E-11+dcgsl_n_18    cgdl = 2.71E-11+dcgdl_n_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 4.14E-7                 jsws = 9.7E-13                
+jswgs = 1.4E-12               cjs = 8.41E-4+dcj_n_18        mjs = 0.31                    
+mjsws = 0.081                 cjsws = 1.02E-10+dcjsw_n_18   cjswgs = 1.2E-10+dcjswg_n_18  
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.7                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.9                    kt1 = -0.235274               
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.32E-10                
+ub1 = 0                       uc1 = 4.355E-11               at = 7E4                      
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.471E-8               kvsat = 0.3                   kvth0 = 2.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 2.1E-3              
+k2we = 0                      ku0we = -4.21E-3              scref = 1E-6                  
}
model pch18 bsim4 {
1:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_p_18                   lmax = 1.1E-5-dxl_p_18                   wmin = 2.0E-6-dxw_p_18                   
+wmax = 1.1E-5-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+dxl_p_18             
+xw = 0.0+dxw_p_18             
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0.0+dlvth0_p_18       wvth0 = 0.0+dwvth0_p_18       
+pvth0 = 0.0+dpvth0_p_18       phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 0.0196662+du0_p_18       lu0 = 0.0+dlu0_p_18           wu0 = 0.0+dwu0_p_18           
+pu0 = 0.0+dpu0_p_18           ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000007E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 65731.5+dvsat_p_18     a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
2:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_p_18                   lmax = 2.0E-6-dxl_p_18                   wmin = 2.0E-6-dxw_p_18                   
+wmax = 1.1E-5-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000007E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
3:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.5E-7                lmax = 1.0E-6-dxl_p_18                   wmin = 2.0E-6-dxw_p_18                   
+wmax = 1.1E-5-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000007E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
4:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_p_18                   lmax = 1.1E-5-dxl_p_18                   wmin = 1.0E-6-dxw_p_18                   
+wmax = 2.0E-6-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.56985E-18              
+wub = -2.999987E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
5:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_p_18                   lmax = 2.0E-6-dxl_p_18                   wmin = 1.0E-6-dxw_p_18                   
+wmax = 2.0E-6-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.56985E-18              
+wub = -2.999987E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
6:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.5E-7                lmax = 1.0E-6-dxl_p_18                   wmin = 1.0E-6-dxw_p_18                   
+wmax = 2.0E-6-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.56985E-18              
+wub = -2.999987E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
7:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_p_18                   lmax = 1.1E-5-dxl_p_18                   wmin = 5.0E-7-dxw_p_18                   
+wmax = 1.0E-6-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000001E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
8:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_p_18                   lmax = 2.0E-6-dxl_p_18                   wmin = 5.0E-7-dxw_p_18                   
+wmax = 1.0E-6-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000001E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
9:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.5E-7                lmax = 1.0E-6-dxl_p_18                   wmin = 5.0E-7-dxw_p_18                   
+wmax = 1.0E-6-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -3.000001E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
10:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_p_18                   lmax = 1.1E-5-dxl_p_18                   wmin = 3.2E-7                 
+wmax = 5.0E-7-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -2.999999E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
11:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_p_18                   lmax = 2.0E-6-dxl_p_18                   wmin = 3.2E-7                 
+wmax = 5.0E-7-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -2.999999E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
12:type=p  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    permod = 1                    
+rgatemod = 0                  wpemod = 0                    
//*** Geometry Range Parameter ***
+lmin = 1.5E-7                lmax = 1.0E-6-dxl_p_18                   wmin = 3.2E-7                 
+wmax = 5.0E-7-dxw_p_18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_p_18               toxm = tox_p_18               
+dtox = 3.1E-10                xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dW and dL Parameter ***
+wint = 1.389287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 0                      ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_p_18               
+xw = 0+dxw_p_18               
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.35906+dvth0_p_18    lvth0 = 0+dlvth0_p_18         wvth0 = 0+dwvth0_p_18         
+pvth0 = 0+dpvth0_p_18         phin = 0                      k1 = 0.25                     
+k2 = -1.21927E-2              k3 = -3.3                     k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** Mobility Related Parameter ***
+u0 = 1.96662E-2+du0_p_18      lu0 = 0+dlu0_p_18             wu0 = 0+dwu0_p_18             
+pu0 = 0+dpu0_p_18             ua = 2.455E-10                ub = 2.569851E-18             
+wub = -2.999999E-25           uc = 4.336286E-11             ud = 0                        
+vsat = 6.57315E4+dvsat_p_18   a0 = 0.693823                 ags = 1.93352                 
+b0 = 0                        b1 = 0                        keta = -6.14042E-2            
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.05137               voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.627693            eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.579679E-3         
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 7.8E-8                bgidl = 2.404E9               
+cgidl = 0.47                  egidl = 0.14                  
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.014               bigbacc = 2.7E-3              cigbacc = 0.121               
+nigbacc = 4.8                 aigbinv = 0.37                bigbinv = 0.028               
+cigbinv = 6.4E-3              eigbinv = 1.2                 nigbinv = 1.5                 
+aigc = 6.8E-3                 bigc = 5.91E-4                cigc = 0                      
+aigsd = 6.1E-3                bigsd = 2.14E-4               cigsd = 0.037                 
+dlcig = 2.21E-9               nigc = 2.31                   poxedge = 1                   
+pigcd = 2.25                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 7.45E41                noib = 1.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.3                      
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 2.2E-11+dcgso_p_18     cgdo = 2.2E-11+dcgdo_p_18     
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.08E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2                      
+voffcv = -0.084               acde = 1.2                    moin = 6.4                    
+cgsl = 1E-10+dcgsl_p_18    cgdl = 1E-10+dcgdl_p_18    
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 3.1E-7                  jsws = 1E-12                  
+jswgs = 2.87E-12              cjs = 9.7E-4+dcj_p_18         mjs = 0.41                    
+mjsws = 0.097                 cjsws = 1.1E-10+dcjsw_p_18    cjswgs = 2.3E-10+dcjswg_p_18  
+mjswgs = 0.88                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.8                  
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1.2192                 kt1 = -0.2061                 
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.0941E-9               
+ub1 = -4.8969E-18             uc1 = -5.5E-11                at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1.2E-7                  kvsat = -0.34                 kvth0 = 1.7E-10               
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = -2E-3               
+k2we = 0                      ku0we = -4.1E-3               scref = 1E-6                  
}
endsection  mos18



section  mos18_na

//  ***********************
//     Mismatch   model   * 
//  ***********************
inline subckt gpdk045_nmos2v_nat ( d g s b ) 
parameters
+l=1e-6 w=1e-6 multi=1 nf=1 factor=1
+dmcg=4E-8 	
+xw=0+dxw_n_na18
+ad=2*dmcg/factor*(w/nf+xw/factor) 
+as=2*dmcg/factor*(w/nf+xw/factor)
+pd=4*dmcg/factor+2*(w/nf+xw/factor) 
+ps=4*dmcg/factor+2*(w/nf+xw/factor)
+nrd=dmcg/factor/(w/nf+xw/factor)
+nrs=dmcg/factor/(w/nf+xw/factor)
+sa=6.1E-7/factor 
+sb=6.1E-7/factor 
+sd=2*dmcg/factor
+sca=1E-6/factor
+scb=1E-6/factor 
+scc=1E-6/factor
+misa1=rn1_na18  misa2=rn2_na18
+fac1=0.279*misa1+0.776*misa2
+fac2=0.279*misa1-0.776*misa2
+lef=l*factor
+wef=w/nf*factor
+geo_fac =1/sqrt(multi*nf*lef*wef*1e12)
+vthmis_n= 0.00303*geo_fac*fac1 
+dlmis_n= 0.00129*geo_fac*lef*fac2 
+dwmis_n= -0.00129*geo_fac*wef*fac2 
+toxmis_n= 0.00129*geo_fac*tox_n_na18*fac2 
gpdk045_nmos2v_nat ( d n1 s b ) nch18_na w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
//********include rg model ***************//
include "gpdk045_mos.scs"   section = res_rg
xrg ( g n1 ) ressnpoly_rg  ll=(w/3/nf/nf)*factor+5e-9 ww=l*factor  mf =multi
model nch18_na bsim4 {
1:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_na18+dlmis_n)      lmax = 1.1E-5-(dxl_n_na18+dlmis_n)      wmin = 2.0E-6-(dxw_n_na18+dwmis_n)      
+wmax = 1.1E-5-(dxw_n_na18+dwmis_n)      
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na18+toxmis_n             toxm = tox_n_na18+toxmis_n             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+(dxl_n_na18+dlmis_n)           
+xw = 0.0+(dxw_n_na18+dwmis_n)           
//*** flicker noise model parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.0037+dvth0_n_na18+vthmis_n   lvth0 = 0.0+dlvth0_n_na18     wvth0 = 0.0+dwvth0_n_na18     
+pvth0 = 0.0+dpvth0_n_na18     phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0368009+du0_n_na18     lu0 = 0.0+dlu0_n_na18         wu0 = 0.0+dwu0_n_na18         
+pu0 = 0.0+dpu0_n_na18         ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 172660.5+dvsat_n_na18  
+wvsat = 2.299969E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** gate dielectric tunneling current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0.0+dcgsl_n_na18       cgdl = 0.0+dcgdl_n_na18       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
2:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 8E-7                   lmax = 2.0E-6-(dxl_n_na18+dlmis_n)      wmin = 2.0E-6-(dxw_n_na18+dwmis_n)      
+wmax = 1.1E-5-(dxw_n_na18+dwmis_n)      
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na18+toxmis_n             toxm = tox_n_na18+toxmis_n             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na18+dlmis_n)             
+xw = 0+(dxw_n_na18+dwmis_n)             
//*** flicker noise model parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -3.7E-3+dvth0_n_na18+vthmis_n   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.299969E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** gate dielectric tunneling current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
3:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_na18+dlmis_n)      lmax = 1.1E-5-(dxl_n_na18+dlmis_n)      wmin = 1.2E-6-(dxw_n_na18+dwmis_n)      
+wmax = 2.0E-6-(dxw_n_na18+dwmis_n)      
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na18+toxmis_n             toxm = tox_n_na18+toxmis_n             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na18+dlmis_n)             
+xw = 0+(dxw_n_na18+dwmis_n)             
//*** flicker noise model parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -3.7E-3+dvth0_n_na18+vthmis_n   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.300083E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -5.000024E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** gate dielectric tunneling current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
4:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 8E-7                   lmax = 2.0E-6-(dxl_n_na18+dlmis_n)      wmin = 1.2E-6-(dxw_n_na18+dwmis_n)      
+wmax = 2.0E-6-(dxw_n_na18+dwmis_n)      
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na18+toxmis_n             toxm = tox_n_na18+toxmis_n             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na18+dlmis_n)             
+xw = 0+(dxw_n_na18+dwmis_n)             
//*** flicker noise model parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -3.7E-3+dvth0_n_na18+vthmis_n   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.300083E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -5.000024E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** gate dielectric tunneling current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
5:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n_na18+dlmis_n)      lmax = 1.1E-5-(dxl_n_na18+dlmis_n)      wmin = 5E-7                   
+wmax = 1.2E-6-(dxw_n_na18+dwmis_n)      
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na18+toxmis_n             toxm = tox_n_na18+toxmis_n             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na18+dlmis_n)             
+xw = 0+(dxw_n_na18+dwmis_n)             
//*** flicker noise model parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -3.7E-3+dvth0_n_na18+vthmis_n   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.299983E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -4.999963E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** gate dielectric tunneling current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
6:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 8E-7                   lmax = 2.0E-6-(dxl_n_na18+dlmis_n)      wmin = 5E-7                   
+wmax = 1.2E-6-(dxw_n_na18+dwmis_n)      
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n_na18+toxmis_n             toxm = tox_n_na18+toxmis_n             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n_na18+dlmis_n)             
+xw = 0+(dxw_n_na18+dwmis_n)             
//*** flicker noise model parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -3.7E-3+dvth0_n_na18+vthmis_n   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.299983E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -4.999963E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** gate dielectric tunneling current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
}

ends gpdk045_nmos2v_nat

model nch18_na bsim4 {
1:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_na18                   lmax = 1.1E-5-dxl_n_na18                   wmin = 2.0E-6-dxw_n_na18                   
+wmax = 1.1E-5-dxw_n_na18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na18             toxm = tox_n_na18             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+dxl_n_na18           
+xw = 0.0+dxw_n_na18           
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -0.0037+dvth0_n_na18   lvth0 = 0.0+dlvth0_n_na18     wvth0 = 0.0+dwvth0_n_na18     
+pvth0 = 0.0+dpvth0_n_na18     phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0368009+du0_n_na18     lu0 = 0.0+dlu0_n_na18         wu0 = 0.0+dwu0_n_na18         
+pu0 = 0.0+dpu0_n_na18         ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 172660.5+dvsat_n_na18  
+wvsat = 2.299969E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0.0+dcgsl_n_na18       cgdl = 0.0+dcgdl_n_na18       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
2:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 8.0E-7                   lmax = 2.0E-6-dxl_n_na18                   wmin = 2.0E-6-dxw_n_na18                   
+wmax = 1.1E-5-dxw_n_na18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na18             toxm = tox_n_na18             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na18             
+xw = 0+dxw_n_na18             
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -3.7E-3+dvth0_n_na18   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.299969E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -4.999975E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
