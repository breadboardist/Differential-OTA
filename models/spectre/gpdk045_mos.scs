+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
3:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_na18                   lmax = 1.1E-5-dxl_n_na18                   wmin = 1.2E-6-dxw_n_na18                 
+wmax = 2.0E-6-dxw_n_na18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na18             toxm = tox_n_na18             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na18             
+xw = 0+dxw_n_na18             
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -3.7E-3+dvth0_n_na18   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.300083E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -5.000024E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
4:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 8.0E-7                   lmax = 2.0E-6-dxl_n_na18                   wmin = 1.2E-6-dxw_n_na18                 
+wmax = 2.0E-6-dxw_n_na18                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na18             toxm = tox_n_na18             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na18             
+xw = 0+dxw_n_na18             
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -3.7E-3+dvth0_n_na18   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.300083E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -5.000024E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
5:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n_na18                   lmax = 1.1E-5-dxl_n_na18                   wmin = 5.0E-7                   
+wmax = 1.2E-6-dxw_n_na18                 
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na18             toxm = tox_n_na18             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na18             
+xw = 0+dxw_n_na18             
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -3.7E-3+dvth0_n_na18   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.299983E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -4.999963E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
6:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 8.0E-7                   lmax = 2.0E-6-dxl_n_na18                   wmin = 5.0E-7                   
+wmax = 1.2E-6-dxw_n_na18                 
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n_na18             toxm = tox_n_na18             
+dtox = 2.9E-10                xj = 8.1E-8                   ndep = 3E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n_na18             
+xw = 0+dxw_n_na18             
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = -3.7E-3+dvth0_n_na18   lvth0 = 0+dlvth0_n_na18       wvth0 = 0+dwvth0_n_na18       
+pvth0 = 0+dpvth0_n_na18       phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -5.68454                 k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 3.68009E-2+du0_n_na18    lu0 = 0+dlu0_n_na18           wu0 = 0+dwu0_n_na18           
+pu0 = 0+dpu0_n_na18           ua = -2.19994E-10             ub = 1.14579E-18              
+uc = 7.758295E-11             ud = 0                        vsat = 1.726605E5+dvsat_n_na18 
+wvsat = 2.299983E-3           a0 = 0.78155                  ags = 0.95168                 
+wags = -4.999963E-8           b0 = 0                        b1 = 0                        
+keta = -5.19382E-2            a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.155578              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.621754            eta0 = 1.804707E-3            etab = -1.26845E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.239489               pdiblc1 = 4.53031E-4          pdiblc2 = 7.801573E-3         
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 0.9                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 1.505E-7              bgidl = 2.43E9                
+cgidl = 0.24                  egidl = 0.2734                
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.024               bigbacc = 2.14E-3             cigbacc = 0.3                 
+nigbacc = 6.4                 aigbinv = 0.018               bigbinv = 5.1E-3              
+cigbinv = 5.24E-3             eigbinv = 1.24                nigbinv = 5.7                 
+aigc = 0.017                  bigc = 1.81E-3                cigc = 5.2E-4                 
+aigsd = 0.0108                bigsd = 1.54E-3               cigsd = 0.067                 
+dlcig = 2.37E-9               nigc = 2.75                   poxedge = 1                   
+pigcd = 2.51                  ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 3.1E41                 noib = 2.24E21                noic = 3E8                    
+em = 1E6                      ef = 0.81                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 6.13E-11+dcgso_n_na18  cgdo = 6.13E-11+dcgdo_n_na18  
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 6.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                dwc = 0                       noff = 1.8                    
+voffcv = -0.065               acde = 1                      moin = 7.1                    
+cgsl = 0+dcgsl_n_na18         cgdl = 0+dcgdl_n_na18         
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 9.4E-7                  jsws = 1.6E-12                
+jswgs = 9.2E-12               cjs = 1.41E-4+dcj_n_na18      mjs = 0.39                    
+mjsws = 0.079                 cjsws = 2.1E-10+dcjsw_n_na18  cjswgs = 1.12E-10+dcjswg_n_na18 
+mjswgs = 0.561                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.73                 
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -0.95                   kt1 = -0.20098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 8.7E-10                 
+ub1 = -3.71E-19               uc1 = 7.29E-11                at = 7.6E4                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -2.1E-8                 kvsat = 0.27                  kvth0 = 1.1E-9                
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 7.3E-9                 
+wku0 = 6.6E-8                 pku0 = 5.2E-14                lkvth0 = -2.16E-11            
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = 0                       wec = 0                       kvth0we = 1.8E-3              
+k2we = 0                      ku0we = -2.21E-3              scref = 1E-6                  
}
endsection  mos18_na


//  ***********************************************************************************
//	MOS in n-well varactor model
//  ***********************************************************************************

section tt_mos_var
parameters cgmin_v=1 dcg_v=1 dxl_v=0  dxw_v=0
include "gpdk045_mos.scs" section=mos_varactor
endsection tt_mos_var

section ff_mos_var
parameters cgmin_v=1.12 dcg_v=1.021 dxl_v=-4.4E-9   dxw_v=9E-9
include "gpdk045_mos.scs" section=mos_varactor
endsection ff_mos_var


section ss_mos_var
parameters cgmin_v=0.88 dcg_v=0.979 dxl_v=4.4E-9   dxw_v=-9E-9
include "gpdk045_mos.scs" section=mos_varactor
endsection ss_mos_var

section mc_mos_var
parameters 
+a1_v=random1 a2_v=random2
+cgmin_v=1+4.56e-3*a1_v+0.038578*a2_v
+dcg_v=1-3.98e-4*a1_v+6.85e-3*a2_v
+dxl_v=0-5.34e-11*a1_v-1.434e-9*a2_v
+dxw_v=-0+2.3e-10*a1_v+2.92e-9*a2_v
include "gpdk045_mos.scs" section=mos_varactor
endsection mc_mos_var


section  mos_varactor
subckt gpdk045_mosvar1v (n1 n2)
parameters ww=1u ll=1u factor=1 multi=1
+xl=0
+xw=0
+area=(ll*factor-xl+dxl_v)*(ww*factor-xw+dxw_v)
+pl=2*(ll*factor-xl+dxl_v)
+pw=2*(ww*factor-xw+dxw_v)
+cgmin=(1.85e-3*area+1.02e-10*pl+8.1e-11*pw)*cgmin_v
+dcg=(5.87e-3*area+3.7e-12*pl-1.85e-11*pw)*dcg_v
+dvg=-0.076-6.5E-05*(temp-25)
+vgnorm=0.33+3.4E-04*(temp-25)
cg ( n1 n2 ) bsource q=multi*((cgmin+dcg)*v(n1,n2)+vgnorm*dcg*log(cosh((v(n1,n2)-dvg)/vgnorm))/log(2.71828))
ends mosvar 
endsection mos_varactor



//  ***********************************************************************************
//	1.8V MOS in n-well varactor model
//  ***********************************************************************************

section tt_mos18_var
parameters cgmin_v18=1 dcg_v18=1 dxl_v18=0  dxw_v18=0
include "gpdk045_mos.scs" section=mos_varactor18
endsection tt_mos18_var

section ff_mos18_var
parameters cgmin_v18=1.12 dcg_v18=1.051 dxl_v18=-9E-9   dxw_v18=9E-9
include "gpdk045_mos.scs" section=mos_varactor18
endsection ff_mos18_var


section ss_mos18_var
parameters cgmin_v18=0.88 dcg_v18=0.949 dxl_v18=9E-9   dxw_v18=-9E-9
include "gpdk045_mos.scs" section=mos_varactor18
endsection ss_mos18_var

section mc_mos18_var
parameters 
+a1_v18=random13 a2_v18=random14
+cgmin_v18=1-1.46e-3*a1_v18+0.038578*a2_v18
+dcg_v18=1-2.488e-3*a1_v18+0.01585*a2_v18
+dxl_v18=0-4.806e-10*a1_v18-2.901e-9*a2_v18
+dxw_v18=-0+2.3e-10*a1_v18+2.92e-9*a2_v18
include "gpdk045_mos.scs" section=mos_varactor18
endsection mc_mos18_var


section mos_varactor18
subckt gpdk045_mosvar2v (n1 n2)
parameters ww=1u ll=1u factor=1 multi=1
+xl=0
+xw=0
+area=(ll*factor-xl+dxl_v18)*(ww*factor-xw+dxw_v18)
+pl=2*(ll*factor-xl+dxl_v18)
+pw=2*(ww*factor-xw+dxw_v18)
+cgmin=(1.03e-3*area+9.46e-11*pl+1.12e-10*pw)*cgmin_v18
+dcg=(3.988e-3*area+1.97e-11*pl-4.8e-11*pw)*dcg_v18
+dvg=-0.158-4.1E-05*(temp-25)
+vgnorm=0.45+5.1E-04*(temp-25)
cg ( n1 n2 ) bsource q=multi*((cgmin+dcg)*v(n1,n2)+vgnorm*dcg*log(cosh((v(n1,n2)-dvg)/vgnorm))/log(2.71828))
ends mosvar_18 
endsection mos_varactor18



//  ***********************************************************************************
//	Resistor model for RG
//  ***********************************************************************************

section res_rg
//  *********************************   N+ Poly Resistor (salicide) *********************************
                       
subckt ressnpoly_rg ( n1 n2 ) 
parameters ll=1.0e-6 ww=1.0e-6 mf=1.0 
+ dxw_ressnpoly = 0             pvc1 = 1.51e-6                
+ pvc2 = 1.13e-12               ptc1 = 3.32e-3                ptc2 = -1.71e-6  
+rsh = 15             dw = dxw_ressnpoly            pt = temp                 
+tfac = 1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0) 
r1 ( n1 n2 ) bsource r=rsh/mf*ll/(ww-dw)*(1+pvc1*(abs(v(n2,n1))/ll)+pvc2*(v(n2,n1)/ll)*(v(n2,n1)/ll))*tfac
ends ressnpoly_rg


//  *********************************   P+ Poly Resistor (salicide) *********************************

subckt ressppoly_rg ( n1 n2 ) 
parameters  ll=1.0e-6 ww=1.0e-6 mf=1.0 
+ dxw_ressppoly = 0             pvc1 = 1.82e-6                
+ pvc2 = 1.23e-12               ptc1 = 3.28e-3                ptc2 = -1.09e-6        
+rsh = 15             dw = dxw_ressppoly            pt = temp                
+tfac = 1.0+ptc1*(pt-25.0)+ptc2*(pt-25.0)*(pt-25.0) 
r1 ( n1 n2 ) bsource r=rsh/mf*ll/(ww-dw)*(1+pvc1*(abs(v(n2,n1))/ll)+pvc2*(v(n2,n1)/ll)*(v(n2,n1)/ll))*tfac
ends ressppoly_rg

endsection res_rg

endlibrary  gpdk045

