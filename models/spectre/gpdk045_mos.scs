simulator lang=spectre
library  gpdk045
//  ******************************************************************************
//  ****************************************************************************
//                                                                             *
//        THIS MODEL LIB CONTAINS :                                            *
//                                                                             *
//        1.LIB TT							       *
//              FF							       *
//		SS							       *	
//		FS							       *
//		SF							       *	
//		MC                                               	       *
//    ( 1.1V Standard-Vt devices with different geometric,statistical, mimatch *
//	     and corner models. )					       *
//                                                                             *
//        2.LIB TT_hvt							       *
//	        FF_hvt                                                         *
//	        SS_hvt                                                         *
//	        FS_hvt                                                         *
//	        SF_hvt                                                         *
//	        MC_hvt                                                         *
//    ( 1.1V High-Vt devices with different geometric, statistical, mismatch   *
//	     and corner models.)    		       			       *
//                                                                             *
//        3.LIB TT_lvt                                                         *
//	        FF_lvt                                                         *
//	        SS_lvt                                                         *
//	        FS_lvt                                                         *
//	        SF_lvt                                                         *
//	        MC_lvt                                                         *
//    ( 1.1V low-Vt devices with different geometric, statistical, mismatch    *
//             and corner models. )    		       			       *
//                                                                             *
//                                                                             *
//        4.LIB TT_na                                                          *
//	        FF_na                                                          *
//	        SS_na                                                          *
//	        FS_na                                                          *
//	        SF_na                                                          *
//	        MC_na                                                          *
//    ( 1.1V native devices with different geometric, statistical, mismatch    *
//	     and corner models.  )    		        		       *
//                                                                             *
//        5.LIB TT_18                                                          *
//	        FF_18                                                          *
//	        SS_18                                                          *
//	        FS_18                                                          *
//	        SF_18                                                          *
//	        MC_18                                                          *
//    ( 1.8V devices with different geometric, statistical, mismatch and       *
//	     corner models.  )    		               		       *
//                                                                             *
//        3.LIB TT_na18                                                        *
//              FF_na18                                                        *
//              SS_na18                                                        *
//              FS_na18                                                        *
//              SF_na18                                                        *
//              MC_na18                                                        *
//    ( 1.8V native devices with different geometric, statistical, mismatch    *
//	     and corner models.  )    		       			       *


section stat_mis_std
parameters
+rn1=0 	rn2=0   rp1=0	rp2=0
statistics { 
 mismatch { 
  vary rn1 dist=gauss std=1/1 
  vary rn2 dist=gauss std=1/1 
  vary rp1 dist=gauss std=1/1 
  vary rp2 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_std
 
section stat_mis_hvt 
parameters
+rn1_hvt=0 	rn2_hvt=0   rp1_hvt=0	rp2_hvt=0
statistics { 
 mismatch { 
  vary rn1_hvt dist=gauss std=1/1 
  vary rn2_hvt dist=gauss std=1/1 
  vary rp1_hvt dist=gauss std=1/1 
  vary rp2_hvt dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_hvt 
section stat_mis_lvt 
parameters
+rn1_lvt=0 	rn2_lvt=0   rp1_lvt=0	rp2_lvt=0
statistics { 
 mismatch { 
  vary rn1_lvt dist=gauss std=1/1 
  vary rn2_lvt dist=gauss std=1/1 
  vary rp1_lvt dist=gauss std=1/1 
  vary rp2_lvt dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_lvt 

section stat_mis_na 
parameters
+rn1_na=0 	rn2_na=0
statistics { 
 mismatch { 
  vary rn1_na dist=gauss std=1/1 
  vary rn2_na dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_na 


section stat_mis_18 
parameters
+rn1_18=0 	rn2_18=0   rp1_18=0	rp2_18=0
statistics { 
 mismatch { 
  vary rn1_18 dist=gauss std=1/1 
  vary rn2_18 dist=gauss std=1/1 
  vary rp1_18 dist=gauss std=1/1 
  vary rp2_18 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_18 

section stat_mis_18na 
parameters
+rn1_na18=0 	rn2_na18=0
statistics { 
 mismatch { 
  vary rn1_na18 dist=gauss std=1/1 
  vary rn2_na18 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_18na 



section stat
parameters
+random1 = 0                   random2 = 0                   random3 = 0                   
+random4 = 0    
+random5 = 0                   random6 = 0                   random7 = 0                   
+random8 = 0    
+random9 = 0                   random10 = 0                   random11 = 0                   
+random12 = 0 
+random13 = 0                   random14 = 0                   random15 = 0                   
+random16 = 0  
+random17 = 0                   random18 = 0                   random19 = 0                   
+random20 = 0 
+random21 = 0                   random22 = 0                   random23 = 0                   
+random24 = 0  
statistics {
    process {
        vary random1 dist=gauss std=1/1
        vary random2 dist=gauss std=1/1
        vary random3 dist=gauss std=1/1
        vary random4 dist=gauss std=1/1
        vary random5 dist=gauss std=1/1
        vary random6 dist=gauss std=1/1
        vary random7 dist=gauss std=1/1
        vary random8 dist=gauss std=1/1
        vary random9 dist=gauss std=1/1
        vary random10 dist=gauss std=1/1
        vary random11 dist=gauss std=1/1
        vary random12 dist=gauss std=1/1 
        vary random13 dist=gauss std=1/1
        vary random14 dist=gauss std=1/1
        vary random15 dist=gauss std=1/1
        vary random16 dist=gauss std=1/1
        vary random17 dist=gauss std=1/1
        vary random18 dist=gauss std=1/1
        vary random19 dist=gauss std=1/1
        vary random20 dist=gauss std=1/1
        vary random21 dist=gauss std=1/1
        vary random22 dist=gauss std=1/1
        vary random23 dist=gauss std=1/1
        vary random24 dist=gauss std=1/1                               
        }
    }                         
endsection stat




section  tt
parameters
+tox_n = 2.41E-9               dxl_n = 0                     
+dxw_n = 0                     dvth0_n = 0                   dlvth0_n = 0                  
+dwvth0_n = 0                  dpvth0_n = 0                  du0_n = 0                     
+dlu0_n = 0                    dwu0_n = 0                    dpu0_n = 0                    
+dvsat_n = 0                   dcj_n = 0                     dcjsw_n = 0                   
+dcjswg_n = 0                  dcgso_n = 0                   dcgdo_n = 0                   
+dcgsl_n = 0                   dcgdl_n = 0                   
+tox_p = 2.4E-9                dvth0_p = 0                   dlvth0_p = 0                  
+dwvth0_p = 0                  dpvth0_p = 0                  dxl_p = 0                     
+dxw_p = 0                     du0_p = 0                     dlu0_p = 0                    
+dwu0_p = 0                    dpu0_p = 0                    dvsat_p = 0                   
+dcj_p = 0                     dcjsw_p = 0                   dcjswg_p = 0                  
+dcgso_p = 0                   dcgdo_p = 0                   dcgsl_p = 0                   
+dcgdl_p = 0                   
include "gpdk045_mos.scs"   section = stat_mis_std
include "gpdk045_mos.scs"   section = mos
endsection  tt


section  ff
parameters
+tox_n = 2.37E-9               dxl_n = -4.4E-9               
+dxw_n = 9E-9                  dvth0_n = -0.035              dlvth0_n = -6.4E-10           
+dwvth0_n = -3.58E-9           dpvth0_n = -1.18E-16          du0_n = 6E-5                  
+dlu0_n = -8.1E-11             dwu0_n = -2.2E-11             dpu0_n = -3.84E-18            
+dvsat_n = 0                   dcj_n = -5.682E-5             dcjsw_n = -3.2142E-12         
+dcjswg_n = -1.6896E-11        dcgso_n = 4.98E-12            dcgdo_n = 4.98E-12            
+dcgsl_n = 1.539E-12           dcgdl_n = 1.539E-12           
+tox_p = 2.36E-9               dvth0_p = 0.0292              dlvth0_p = 9E-10              
+dwvth0_p = 2.6E-9             dpvth0_p = 8.7E-17            dxl_p = -4.4E-9               
+dxw_p = 9E-9                  du0_p = 6.8E-4                dlu0_p = -7.8E-11             
+dwu0_p = 2E-12                dpu0_p = -1.34E-17            dvsat_p = 0                   
+dcj_p = -6.5868E-5            dcjsw_p = -4.098E-12          dcjswg_p = -1.6698E-11        
+dcgso_p = 2.79E-12            dcgdo_p = 2.79E-12            dcgsl_p = 4.86E-12            
+dcgdl_p = 4.86E-12            
include "gpdk045_mos.scs"   section = stat_mis_std        
include "gpdk045_mos.scs"   section = mos
endsection  ff

section  ss
parameters
+tox_n = 2.45E-9               dxl_n = 4.4E-9                
+dxw_n = -9E-9                 dvth0_n = 0.036               dlvth0_n = 8.42E-10           
+dwvth0_n = 2.976E-9           dpvth0_n = 1.18E-16           du0_n = -2.07E-4              
+dlu0_n = 1.172E-10            dwu0_n = -6.33E-11            dpu0_n = 9.342E-18            
+dvsat_n = 0                   dcj_n = 5.682E-5              dcjsw_n = 3.2142E-12          
+dcjswg_n = 1.6896E-11         dcgso_n = -4.98E-12           dcgdo_n = -4.98E-12           
+dcgsl_n = -1.539E-12          dcgdl_n = -1.539E-12          
+tox_p = 2.44E-9               dvth0_p = -0.029              dlvth0_p = -1.04E-9           
+dwvth0_p = -1.9E-9            dpvth0_p = -9E-17             dxl_p = 4.4E-9                
+dxw_p = -9E-9                 du0_p = -9.6E-4               dlu0_p = 1.18E-10             
+dwu0_p = -1.22E-10            dpu0_p = 1.97E-17             dvsat_p = 0                   
+dcj_p = 6.5868E-5             dcjsw_p = 4.098E-12           dcjswg_p = 1.6698E-11         
+dcgso_p = -2.79E-12           dcgdo_p = -2.79E-12           dcgsl_p = -4.86E-12           
+dcgdl_p = -4.86E-12           
include "gpdk045_mos.scs"   section = stat_mis_std          
include "gpdk045_mos.scs"   section = mos
endsection  ss

section  fs
parameters
+tox_n = 2.41E-9               dxl_n = 0                     
+dxw_n = 0                     dvth0_n = -0.0175             dlvth0_n = -4.13744E-10       
+dwvth0_n = -1.271456E-9       dpvth0_n = -4.57276E-17       du0_n = 7E-5                  
+dlu0_n = -2.1E-11             dwu0_n = 7.641E-11            dpu0_n = -7.68E-19            
+dvsat_n = 0                   dcj_n = -5.682E-5             dcjsw_n = -3.2142E-12         
+dcjswg_n = -1.6896E-11        dcgso_n = 0                   dcgdo_n = 0                   
+dcgsl_n = 0                   dcgdl_n = 0                   
+tox_p = 2.4E-9                dvth0_p = -0.0145             dlvth0_p = -3.8E-10           
+dwvth0_p = -9.5E-10           dpvth0_p = -9E-18             dxl_p = 0                     
+dxw_p = 0                     du0_p = -4.8E-4               dlu0_p = 3.5E-11              
+dwu0_p = -1.27E-10            dpu0_p = -8.2E-18             dvsat_p = 0                   
+dcj_p = 6.5868E-5             dcjsw_p = 4.098E-12           dcjswg_p = 1.6698E-11         
+dcgso_p = 0                   dcgdo_p = 0                   dcgsl_p = 0                   
+dcgdl_p = 0                   
include "gpdk045_mos.scs"   section = stat_mis_std    
include "gpdk045_mos.scs"   section = mos
endsection  fs

section  sf
parameters
+tox_n = 2.41E-9               dxl_n = 0                     
+dxw_n = 0                     dvth0_n = 0.018               dlvth0_n = 3.61E-10           
+dwvth0_n = 1.088E-9           dpvth0_n = 5.1E-17            du0_n = -1.0825E-4            
+dlu0_n = 1.86E-11             dwu0_n = -1.023E-10           dpu0_n = 1.67232E-18          
+dvsat_n = 0                   dcj_n = 5.682E-5              dcjsw_n = 3.2142E-12          
+dcjswg_n = 1.6896E-11         dcgso_n = 0                   dcgdo_n = 0                   
+dcgsl_n = 0                   dcgdl_n = 0                   
+tox_p = 2.4E-9                dvth0_p = 0.0136              dlvth0_p = 4.6E-10            
+dwvth0_p = 1.2E-9             dpvth0_p = 2.55E-17           dxl_p = 0                     
+dxw_p = 0                     du0_p = 4.6E-4                dlu0_p = -4E-11               
+dwu0_p = 8.948E-11            dpu0_p = -1.4E-18             dvsat_p = 0                   
+dcj_p = -6.5868E-5            dcjsw_p = -4.098E-12          dcjswg_p = -1.6698E-11        
+dcgso_p = 0                   dcgdo_p = 0                   dcgsl_p = 0                   
+dcgdl_p = 0                   
include "gpdk045_mos.scs"   section = stat_mis_std
include "gpdk045_mos.scs"   section = mos
endsection  sf

section mc
parameters
+a1 = random1                  a2 = random2                  
+a3 = random3                  a4 = random4       

parameters
+tox_n = 2.41e-9-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4 
+dxl_n = 0-3.1e-11*a1-1.4e-9*a2-1.405e-10*a3+3.7e-10*a4 
+dxw_n = 0+1.8797e-10*a1+2.7e-9*a2-9.5e-10*a3-2.3e-10*a4 
+dvth0_n = 0-6.3e-3*a1-4.9519e-3*a2+6.3164e-3*a3+3.8623e-3*a4 
+dlvth0_n = 0-6.89e-11*a1-1.83e-10*a2+2.4158e-10*a3-7.5252e-11*a4 
+dwvth0_n = 0-2.9703e-10*a1-5.39e-11*a2+7.373e-10*a3+3.3967e-10*a4 
+dpvth0_n = 0-4.32e-17*a1+4.786e-18*a2+1.49e-17*a3+2.8e-17*a4 
+du0_n = 0+8e-5*a1-4.848e-5*a2-7.86e-5*a3+2.8e-17*a4 
+dlu0_n = 0-2.1e-12*a1-2.7e-11*a2+1.48e-11*a3-1.1e-12*a4 
+dwu0_n = 0-1.13e-11*a1+1.4e-11*a2-3.62e-11*a3-3e-12*a4 
+dpu0_n = 0+5e-19*a1-2.4e-19*a2+3.751e-18*a3-3.4e-19*a4 
+dvsat_n = 0+0*a1+0*a2+0*a3+0*a4 
+dcgso_n = -0.1245*(-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4) 
+dcgdo_n = -0.1245*(-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4) 
+dcgsl_n = -0.0385*(-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4) 
+dcgdl_n = -0.0385*(-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4) 
+dcj_n = 1.14e-5*a1-5.2e-6*a2-1.31e-5*a3+1.34e-6*a4 
+dcjsw_n = 5.66e-8*(1.14e-5*a1-5.2e-6*a2-1.31e-5*a3+1.34e-6*a4) 
+dcjswg_n = 2.975e-7*(1.14e-5*a1-5.2e-6*a2-1.31e-5*a3+1.34e-6*a4)
+tox_p = 2.4e-9-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4 
+dxl_p = 0-3.1e-11*a1-1.4e-9*a2-1.405e-10*a3+3.7e-10*a4 
+dxw_p = 0+1.8797e-10*a1+2.7e-9*a2-9.5e-10*a3-2.3e-10*a4 
+dvth0_p = 0-5.50872e-3*a1-3.06696e-3*a2+5.860787e-3*a3+3.048809e-3*a4 
+dlvth0_p = 0-2.9e-11*a1-1.7e-10*a2+2.158e-10*a3-7.5252e-11*a4 
+dwvth0_p = 0-2.003e-10*a1-6.539e-10*a2+2.073e-10*a3+3.0967e-10*a4 
+dpvth0_p = 0-4.8e-18*a1+4.786e-18*a2+2.9e-18*a3+2.8e-17*a4 
+du0_p = 0-1.61018e-4*a1-4.05e-4*a2-4.1196e-6*a3+2.8e-17*a4 
+dlu0_p = 0+2.5e-11*a1+2.053e-11*a2+8e-13*a3+2e-12*a4 
+dwu0_p = 0-7.13e-11*a1-8.154e-11*a2-2e-13*a3+3.1e-11*a4 
+dpu0_p = 0+9.98e-19*a1-6.921e-18*a2-2.1e-19*a3-1.94e-18*a4 
+dvsat_p = 0+0*a1+0*a2+0*a3+0*a4 
+dcgso_p = -0.06975*(-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4) 
+dcgdo_p = -0.06975*(-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4) 
+dcgsl_p = -0.1215*(-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4) 
+dcgdl_p = -0.1215*(-3.4e-13*a1-1.1903e-11*a2-5.1e-13*a3+5.7697e-12*a4) 
+dcj_p = 1.443e-5*a1-5.55e-6*a2-1.42e-5*a3+9.4e-7*a4 
+dcjsw_p = 6.22e-8*(1.443e-5*a1-5.55e-6*a2-1.42e-5*a3+9.4e-7*a4) 
+dcjswg_p = 2.536e-7*(1.443e-5*a1-5.55e-6*a2-1.42e-5*a3+9.4e-7*a4)  
include "gpdk045_mos.scs"   section = stat_mis_std  
include "gpdk045_mos.scs"   section = mos
endsection mc


section  tt_hvt
parameters
+tox_n_hvt = 2.41E-9           dxl_n_hvt = 0                 
+dxw_n_hvt = 0                 dvth0_n_hvt = 0               dlvth0_n_hvt = 0              
+dwvth0_n_hvt = 0              dpvth0_n_hvt = 0              du0_n_hvt = 0                 
+dlu0_n_hvt = 0                dwu0_n_hvt = 0                dpu0_n_hvt = 0                
+dvsat_n_hvt = 0               dcj_n_hvt = 0                 dcjsw_n_hvt = 0               
+dcjswg_n_hvt = 0              dcgso_n_hvt = 0               dcgdo_n_hvt = 0               
+dcgsl_n_hvt = 0               dcgdl_n_hvt = 0               
+tox_p_hvt = 2.4E-9            dxl_p_hvt = 0                 dxw_p_hvt = 0                 
+dvth0_p_hvt = 0               dlvth0_p_hvt = 0              dwvth0_p_hvt = 0              
+dpvth0_p_hvt = 0              du0_p_hvt = 0                 dlu0_p_hvt = 0                
+dwu0_p_hvt = 0                dpu0_p_hvt = 0                dvsat_p_hvt = 0               
+dcj_p_hvt = 0                 dcjsw_p_hvt = 0               dcjswg_p_hvt = 0              
+dcgso_p_hvt = 0               dcgdo_p_hvt = 0               dcgsl_p_hvt = 0               
+dcgdl_p_hvt = 0               
include "gpdk045_mos.scs"   section = stat_mis_hvt
include "gpdk045_mos.scs"   section = mos_hvt
endsection  tt_hvt

section  ff_hvt
parameters
+tox_n_hvt = 2.37E-9           dxl_n_hvt = -4.2E-9           
+dxw_n_hvt = 6E-9              dvth0_n_hvt = -0.0354         dlvth0_n_hvt = -7.7E-10       
+dwvth0_n_hvt = -3.4E-9        dpvth0_n_hvt = -9.5E-17       du0_n_hvt = -3E-5             
+dlu0_n_hvt = -8.86E-11        dwu0_n_hvt = -1E-11           dpu0_n_hvt = -3.02E-18        
+dvsat_n_hvt = 0               dcj_n_hvt = -6.6E-5           dcjsw_n_hvt = -2.706E-12      
+dcjswg_n_hvt = -2.059E-11     dcgso_n_hvt = 4.527E-12       dcgdo_n_hvt = 4.527E-12       
+dcgsl_n_hvt = 1.089E-12       dcgdl_n_hvt = 1.089E-12       
+tox_p_hvt = 2.36E-9           dxl_p_hvt = -4.41E-9          dxw_p_hvt = 9E-9              
+dvth0_p_hvt = 0.0296          dlvth0_p_hvt = 9E-10          dwvth0_p_hvt = 3E-9           
+dpvth0_p_hvt = -8E-18         du0_p_hvt = 5.2E-4            dlu0_p_hvt = -9.8E-11         
+dwu0_p_hvt = -4.4E-11         dpu0_p_hvt = -5.8E-18         dvsat_p_hvt = 0               
+dcj_p_hvt = -7.92E-6          dcjsw_p_hvt = -3.366E-12      dcjswg_p_hvt = -2.066E-11     
+dcgso_p_hvt = 2.61E-12        dcgdo_p_hvt = 2.61E-12        dcgsl_p_hvt = 2.16E-12        
+dcgdl_p_hvt = 2.16E-12        
include "gpdk045_mos.scs"   section = stat_mis_hvt
include "gpdk045_mos.scs"   section = mos_hvt
endsection  ff_hvt

section  ss_hvt
parameters
+tox_n_hvt = 2.45E-9           dxl_n_hvt = 4.2E-9            
+dxw_n_hvt = -6E-9             dvth0_n_hvt = 0.0327          dlvth0_n_hvt = 9.5E-10        
+dwvth0_n_hvt = 2.94E-9        dpvth0_n_hvt = 1.14E-16       du0_n_hvt = -1.8E-4           
+dlu0_n_hvt = 1.391E-10        dwu0_n_hvt = -8.7E-11         dpu0_n_hvt = 1.01E-17         
+dvsat_n_hvt = 0               dcj_n_hvt = 6.6E-5            dcjsw_n_hvt = 2.706E-12       
+dcjswg_n_hvt = 2.059E-11      dcgso_n_hvt = -4.527E-12      dcgdo_n_hvt = -4.527E-12      
+dcgsl_n_hvt = -1.089E-12      dcgdl_n_hvt = -1.089E-12      
+tox_p_hvt = 2.44E-9           dxl_p_hvt = 4.41E-9           dxw_p_hvt = -9E-9             
+dvth0_p_hvt = -0.02844        dlvth0_p_hvt = -1.2E-9        dwvth0_p_hvt = -1.6E-9        
+dpvth0_p_hvt = -1.16E-16      du0_p_hvt = -8.8E-4           dlu0_p_hvt = 1.74E-10         
+dwu0_p_hvt = -1.36E-10        dpu0_p_hvt = 3.16E-17         dvsat_p_hvt = 0               
+dcj_p_hvt = -7.92E-6          dcjsw_p_hvt = -3.366E-12      dcjswg_p_hvt = -2.066E-11     
+dcgso_p_hvt = 2.61E-12        dcgdo_p_hvt = 2.61E-12        dcgsl_p_hvt = 2.16E-12        
+dcgdl_p_hvt = 2.16E-12        
include "gpdk045_mos.scs"   section = stat_mis_hvt
include "gpdk045_mos.scs"   section = mos_hvt
endsection  ss_hvt

section  fs_hvt
parameters
+tox_n_hvt = 2.41E-9           dxl_n_hvt = 0                 
+dxw_n_hvt = 0                 dvth0_n_hvt = -0.0188         dlvth0_n_hvt = -2.85E-10      
+dwvth0_n_hvt = -1.4E-9        dpvth0_n_hvt = -4.15E-17      du0_n_hvt = -7.4E-5           
+dlu0_n_hvt = -2.49E-11        dwu0_n_hvt = 6.4E-11          dpu0_n_hvt = -2.52E-18        
+dvsat_n_hvt = 0               dcj_n_hvt = -6.6E-5           dcjsw_n_hvt = -2.706E-12      
+dcjswg_n_hvt = -2.059E-11     dcgso_n_hvt = 0               dcgdo_n_hvt = 0               
+dcgsl_n_hvt = 0               dcgdl_n_hvt = 0               
+tox_p_hvt = 2.4E-9            dxl_p_hvt = 0                 dxw_p_hvt = 0                 
+dvth0_p_hvt = -0.01322        dlvth0_p_hvt = -5E-10         dwvth0_p_hvt = -7E-10         
+dpvth0_p_hvt = -4.55E-17      du0_p_hvt = -5E-4             dlu0_p_hvt = 5.4E-11          
+dwu0_p_hvt = -1.4E-10         dpu0_p_hvt = 6.1E-18          dvsat_p_hvt = 0               
+dcj_p_hvt = -7.92E-6          dcjsw_p_hvt = -3.366E-12      dcjswg_p_hvt = -2.066E-11     
+dcgso_p_hvt = 0               dcgdo_p_hvt = 0               dcgsl_p_hvt = 0               
+dcgdl_p_hvt = 0               
include "gpdk045_mos.scs"   section = stat_mis_hvt
include "gpdk045_mos.scs"   section = mos_hvt
endsection  fs_hvt

section  sf_hvt
parameters
+tox_n_hvt = 2.41E-9           dxl_n_hvt = 0                 
+dxw_n_hvt = 0                 dvth0_n_hvt = 0.01627         dlvth0_n_hvt = 3.75E-10       
+dwvth0_n_hvt = 1.27E-9        dpvth0_n_hvt = 3.6E-17        du0_n_hvt = -1E-4             
+dlu0_n_hvt = 3.7348E-11       dwu0_n_hvt = -9.1E-11         dpu0_n_hvt = 2.25E-18         
+dvsat_n_hvt = 0               dcj_n_hvt = 6.6E-5            dcjsw_n_hvt = 2.706E-12       
+dcjswg_n_hvt = 2.059E-11      dcgso_n_hvt = 0               dcgdo_n_hvt = 0               
+dcgsl_n_hvt = 0               dcgdl_n_hvt = 0               
+tox_p_hvt = 2.4E-9            dxl_p_hvt = 0                 dxw_p_hvt = 0                 
+dvth0_p_hvt = 0.0138          dlvth0_p_hvt = 4.6E-10        dwvth0_p_hvt = 1.7E-9         
+dpvth0_p_hvt = -4E-17         du0_p_hvt = 3.7E-4            dlu0_p_hvt = -5.3E-11         
+dwu0_p_hvt = 4.4E-11          dpu0_p_hvt = 4.892E-18        dvsat_p_hvt = 0               
+dcj_p_hvt = -7.92E-6          dcjsw_p_hvt = -3.366E-12      dcjswg_p_hvt = -2.066E-11     
+dcgso_p_hvt = 0               dcgdo_p_hvt = 0               dcgsl_p_hvt = 0               
+dcgdl_p_hvt = 0               
include "gpdk045_mos.scs"   section = stat_mis_hvt
include "gpdk045_mos.scs"   section = mos_hvt
endsection  sf_hvt


section mc_hvt
parameters
+a5 = random5                  a6 = random6                  
+a7 = random7                  a8 = random8   
+tox_n_hvt = 2.41e-9+5.84e-13*a5-1.303e-11*a6+3.04e-13*a7+2.88485e-13*a8 
+dxl_n_hvt = 0-3.782e-11*a5-1.3e-9*a6-1.9389e-10*a7+4.773e-10*a8 
+dxw_n_hvt = 0-1.31579e-9*a5+1.49e-9*a6-7.03e-10*a7-1.886e-10*a8 
+dvth0_n_hvt = 0-7.308901e-3*a5-6.0868e-3*a6+3.6582e-3*a7+5.763858e-3*a8 
+dlvth0_n_hvt = 0-6.220345e-11*a5-5.49e-11*a6+3.264395e-10*a7-1.324004e-10*a8 
+dwvth0_n_hvt = 0-2.9703e-10*a5-5.139e-10*a6+1.7373e-10*a7+3.3967e-10*a8 
+dpvth0_n_hvt = 0-9.056006e-18*a5-5.4894e-17*a6+3.364179e-18*a7+1.266909e-17*a8 
+du0_n_hvt = 0-1.04591e-5*a5-3.4665e-5*a6-3.970954e-5*a7+1.266909e-17*a8 
+dlu0_n_hvt = 0-1.412762e-12*a5-1.714e-11*a6+2.617e-11*a7+7.439915e-12*a8 
+dwu0_n_hvt = 0+2.13e-11*a5+1.6e-11*a6-4.62e-11*a7-3e-12*a8 
+dpu0_n_hvt = 0-6.5632e-19*a5-3.22407e-18*a6-1.621752e-19*a7-6.461331e-19*a8 
+dvsat_n_hvt = 0+0*a5+0*a6+0*a7+0*a8 
+dcj_n_hvt = 1.54e-5*a5-5.5e-6*a6-1.35e-5*a7+1.34e-6*a8 
+dcjsw_n_hvt = 4.06e-8*(1.54e-5*a5-5.5e-6*a6-1.35e-5*a7+1.34e-6*a8) 
+dcjswg_n_hvt = 3.09e-7*(1.54e-5*a5-5.5e-6*a6-1.35e-5*a7+1.34e-6*a8) 
+dcgso_n_hvt = -0.113*(5.84e-13*a5-1.303e-11*a6+3.04e-13*a7+2.88485e-13*a8) 
+dcgdo_n_hvt = -0.113*(5.84e-13*a5-1.303e-11*a6+3.04e-13*a7+2.88485e-13*a8) 
+dcgsl_n_hvt = -0.0272*(5.84e-13*a5-1.303e-11*a6+3.04e-13*a7+2.88485e-13*a8) 
+dcgdl_n_hvt = -0.0272*(5.84e-13*a5-1.303e-11*a6+3.04e-13*a7+2.88485e-13*a8)
+tox_p_hvt = 2.41e-9-3.4e-13*a5-1.1903e-11*a6-5.1e-13*a7+5.7697e-12*a8 
+dxl_p_hvt = 0-3.1e-11*a5-1.4e-9*a6-1.405e-10*a7+3.7e-10*a8 
+dxw_p_hvt = 0+1.8797e-10*a5+2.7e-9*a6-9.5e-10*a7-2.3e-10*a8 
+dvth0_p_hvt = 0-4.406976e-3*a5-4.66696e-3*a6+5.860787e-3*a7+3.048809e-3*a8 
+dlvth0_p_hvt = 0-1.51827e-10*a5-2.6168e-11*a6+2.361942e-10*a7-7.454963e-11*a8 
+dwvth0_p_hvt = 0-1.8027e-10*a5-5.231e-10*a6+2.073e-10*a7+3.0967e-10*a8 
+dpvth0_p_hvt = 0-1.46e-18*a5+3.086e-18*a6+3.9e-18*a7+7.7e-18*a8 
+du0_p_hvt = 0-2.7018e-5*a5-3.718e-4*a6-4.411961e-6*a7+7.7e-18*a8 
+dlu0_p_hvt = 0+1.9841e-11*a5-1e-12*a6-2.585e-11*a7+5.04455e-12*a8 
+dwu0_p_hvt = 0-7.13e-11*a5-8.713e-11*a6-2e-13*a7+3.1e-11*a8 
+dpu0_p_hvt = 0+1.11e-18*a5-5.174e-18*a6-3.34e-19*a7-1.94e-18*a8 
+dvsat_p_hvt = 0+0*a5+0*a6+0*a7+0*a8 
+dcj_p_hvt = 2.01e-6*a5-6.06e-7*a6-1.404e-6*a7+1.73e-7*a8 
+dcjsw_p_hvt = 4.25e-7*(2.01e-6*a5-6.06e-7*a6-1.404e-6*a7+1.73e-7*a8) 
+dcjswg_p_hvt = 2.608e-6*(2.01e-6*a5-6.06e-7*a6-1.404e-6*a7+1.73e-7*a8) 
+dcgso_p_hvt = -0.0653*(-3.4e-13*a5-1.1903e-11*a6-5.1e-13*a7+5.7697e-12*a8) 
+dcgdo_p_hvt = -0.0653*(-3.4e-13*a5-1.1903e-11*a6-5.1e-13*a7+5.7697e-12*a8) 
+dcgsl_p_hvt = -0.05404*(-3.4e-13*a5-1.1903e-11*a6-5.1e-13*a7+5.7697e-12*a8) 
+dcgdl_p_hvt = -0.05404*(-3.4e-13*a5-1.1903e-11*a6-5.1e-13*a7+5.7697e-12*a8)
include "gpdk045_mos.scs"   section = stat_mis_hvt 
include "gpdk045_mos.scs"   section = mos_hvt
endsection mc_hvt

section  tt_lvt
parameters
+tox_n_lvt = 2.41E-9           dxl_n_lvt = 0                 
+dxw_n_lvt = 0                 dvth0_n_lvt = 0               dlvth0_n_lvt = 0              
+dwvth0_n_lvt = 0              dpvth0_n_lvt = 0              du0_n_lvt = 0                 
+dlu0_n_lvt = 0                dwu0_n_lvt = 0                dpu0_n_lvt = 0                
+dvsat_n_lvt = 0               dcj_n_lvt = 0                 dcjsw_n_lvt = 0               
+dcjswg_n_lvt = 0              dcgso_n_lvt = 0               dcgdo_n_lvt = 0               
+dcgsl_n_lvt = 0               dcgdl_n_lvt = 0               
+tox_p_lvt = 2.4E-9            dxl_p_lvt = 0                 dxw_p_lvt = 0                 
+dvth0_p_lvt = 0               dlvth0_p_lvt = 0              dwvth0_p_lvt = 0              
+dpvth0_p_lvt = 0              du0_p_lvt = 0                 dlu0_p_lvt = 0                
+dwu0_p_lvt = 0                dpu0_p_lvt = 0                dvsat_p_lvt = 0               
+dcj_p_lvt = 0                 dcjsw_p_lvt = 0               dcjswg_p_lvt = 0              
+dcgso_p_lvt = 0               dcgdo_p_lvt = 0               dcgsl_p_lvt = 0               
+dcgdl_p_lvt = 0               
parameters dpvsat_n_lvt = 0
include "gpdk045_mos.scs"   section = stat_mis_lvt
include "gpdk045_mos.scs"   section = mos_lvt
endsection  tt_lvt

section  ff_lvt
parameters
+tox_n_lvt = 2.37E-9           dxl_n_lvt = -3.795E-9         
+dxw_n_lvt = 9.6E-9            dvth0_n_lvt = -0.0364         dlvth0_n_lvt = -5.5E-10       
+dwvth0_n_lvt = -3.6E-9        dpvth0_n_lvt = -1.21E-16      du0_n_lvt = 2.2E-4            
+dlu0_n_lvt = -6E-11           dwu0_n_lvt = -3.3E-11         dpu0_n_lvt = -3.4E-18         
+dvsat_n_lvt = 0               dcj_n_lvt = -4.561E-5         dcjsw_n_lvt = -3.762E-12      
+dcjswg_n_lvt = -1.32E-11      dcgso_n_lvt = 5.247E-12       dcgdo_n_lvt = 5.247E-12       
+dcgsl_n_lvt = 1.89E-12        dcgdl_n_lvt = 1.89E-12        
+tox_p_lvt = 2.36E-9           dxl_p_lvt = -3.81E-9          dxw_p_lvt = 9.6E-9            
+dvth0_p_lvt = 0.029           dlvth0_p_lvt = 8.6E-10        dwvth0_p_lvt = 3.12E-9        
+dpvth0_p_lvt = 1.16E-16       du0_p_lvt = 8.6E-4            dlu0_p_lvt = -6.3E-11         
+dwu0_p_lvt = -4E-11           dpu0_p_lvt = -1.64E-17        dvsat_p_lvt = 0               
+dcj_p_lvt = -5.4648E-5        dcjsw_p_lvt = -4.686E-12      dcjswg_p_lvt = -1.3398E-11    
+dcgso_p_lvt = 3.33E-12        dcgdo_p_lvt = 3.33E-12        dcgsl_p_lvt = 3.6E-12         
+dcgdl_p_lvt = 3.6E-12         
parameters dpvsat_n_lvt = 0
include "gpdk045_mos.scs"   section = stat_mis_lvt
include "gpdk045_mos.scs"   section = mos_lvt
endsection  ff_lvt


section  ss_lvt
parameters
+tox_n_lvt = 2.45E-9           dxl_n_lvt = 3.795E-9          
+dxw_n_lvt = -9.6E-9           dvth0_n_lvt = 0.0338          dlvth0_n_lvt = 8.55E-10       
+dwvth0_n_lvt = 2.96E-9        dpvth0_n_lvt = 9.8E-17        du0_n_lvt = -4.57E-4          
+dlu0_n_lvt = 7.95E-11         dwu0_n_lvt = -4.3E-11         dpu0_n_lvt = 5.14E-18         
+dvsat_n_lvt = 0               dcj_n_lvt = 4.561E-5          dcjsw_n_lvt = 3.762E-12       
+dcjswg_n_lvt = 1.32E-11       dcgso_n_lvt = -5.247E-12      dcgdo_n_lvt = -5.247E-12      
+dcgsl_n_lvt = -1.89E-12       dcgdl_n_lvt = -1.89E-12       
+tox_p_lvt = 2.44E-9           dxl_p_lvt = 3.81E-9           dxw_p_lvt = -9.6E-9           
+dvth0_p_lvt = -0.0272         dlvth0_p_lvt = -1E-9          dwvth0_p_lvt = -2.4E-9        
+dpvth0_p_lvt = -1.1E-16       du0_p_lvt = -1.14E-3          dlu0_p_lvt = 7.4E-11          
+dwu0_p_lvt = -9.8E-11         dpu0_p_lvt = 2.26E-17         dvsat_p_lvt = 0               
+dcj_p_lvt = 5.4648E-5         dcjsw_p_lvt = 4.686E-12       dcjswg_p_lvt = 1.3398E-11     
+dcgso_p_lvt = -3.33E-12       dcgdo_p_lvt = -3.33E-12       dcgsl_p_lvt = -3.6E-12        
+dcgdl_p_lvt = -3.6E-12        
parameters dpvsat_n_lvt = 0
include "gpdk045_mos.scs"   section = stat_mis_lvt
include "gpdk045_mos.scs"   section = mos_lvt
endsection  ss_lvt

section  fs_lvt
parameters
+tox_n_lvt = 2.41E-9           dxl_n_lvt = 0                 
+dxw_n_lvt = 0                 dvth0_n_lvt = -0.0182         dlvth0_n_lvt = -3.4E-10       
+dwvth0_n_lvt = -1.3E-9        dpvth0_n_lvt = -5.05E-17      du0_n_lvt = 2E-4              
+dlu0_n_lvt = -1.082E-11       dwu0_n_lvt = 7.9E-11          dpu0_n_lvt = -4E-19           
+dvsat_n_lvt = 0               dcj_n_lvt = -4.561E-5         dcjsw_n_lvt = -3.762E-12      
+dcjswg_n_lvt = -1.32E-11      dcgso_n_lvt = 0               dcgdo_n_lvt = 0               
+dcgsl_n_lvt = 0               dcgdl_n_lvt = 0               
+tox_p_lvt = 2.4E-9            dxl_p_lvt = 0                 dxw_p_lvt = 0                 
+dvth0_p_lvt = -0.0126         dlvth0_p_lvt = -3.8E-10       dwvth0_p_lvt = -1.4E-9        
+dpvth0_p_lvt = -2.6E-17       du0_p_lvt = -6.4E-4           dlu0_p_lvt = 1.7E-11          
+dwu0_p_lvt = -1.1E-10         dpu0_p_lvt = -1E-18           dvsat_p_lvt = 0               
+dcj_p_lvt = 5.4648E-5         dcjsw_p_lvt = 4.686E-12       dcjswg_p_lvt = 1.3398E-11     
+dcgso_p_lvt = 0               dcgdo_p_lvt = 0               dcgsl_p_lvt = 0               
+dcgdl_p_lvt = 0               
parameters dpvsat_n_lvt = 0
include "gpdk045_mos.scs"   section = stat_mis_lvt
include "gpdk045_mos.scs"   section = mos_lvt
endsection  fs_lvt

section  sf_lvt
parameters
+tox_n_lvt = 2.41E-9           dxl_n_lvt = 0                 
+dxw_n_lvt = 0                 dvth0_n_lvt = 0.016024        dlvth0_n_lvt = 3.97E-10       
+dwvth0_n_lvt = 1.33E-9        dpvth0_n_lvt = 3.94E-17       du0_n_lvt = -2.8E-4           
+dlu0_n_lvt = 1.04E-11         dwu0_n_lvt = -8.5E-11         dpu0_n_lvt = 2E-19            
+dvsat_n_lvt = 0               dcj_n_lvt = 4.561E-5          dcjsw_n_lvt = 3.762E-12       
+dcjswg_n_lvt = 1.32E-11       dcgso_n_lvt = 0               dcgdo_n_lvt = 0               
+dcgsl_n_lvt = 0               dcgdl_n_lvt = 0               
+tox_p_lvt = 2.4E-9            dxl_p_lvt = 0                 dxw_p_lvt = 0                 
+dvth0_p_lvt = 0.0145          dlvth0_p_lvt = 4.1E-10        dwvth0_p_lvt = 1.46E-9        
+dpvth0_p_lvt = 2.8E-17        du0_p_lvt = 5.2E-4            dlu0_p_lvt = -2.45E-11        
+dwu0_p_lvt = 7.6E-11          dpu0_p_lvt = 8E-19            dvsat_p_lvt = 0               
+dcj_p_lvt = -5.4648E-5        dcjsw_p_lvt = -4.686E-12      dcjswg_p_lvt = -1.3398E-11    
+dcgso_p_lvt = 0               dcgdo_p_lvt = 0               dcgsl_p_lvt = 0               
+dcgdl_p_lvt = 0               
parameters dpvsat_n_lvt = 0
include "gpdk045_mos.scs"   section = stat_mis_lvt
include "gpdk045_mos.scs"   section = mos_lvt
endsection  sf_lvt

section mc_lvt  
parameters
+a9 = random9                  a10 = random10                  
+a11 = random11                  a12 = random12   
+tox_n_lvt = 2.41e-9-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12 
+dxl_n_lvt = 0-3.6e-11*a9-1.2e-9*a10-2.0075e-10*a11+3.3e-10*a12 
+dxw_n_lvt = 0+9.3985e-11*a9+3e-9*a10-7.3e-10*a11-2.8e-10*a12 
+dvth0_n_lvt = 0-5.9e-3*a9-5.0519e-3*a10+7.4164e-3*a11+3.6e-3*a12 
+dlvth0_n_lvt = 0-1.0589e-10*a9-8e-11*a10+2.0958e-10*a11-7.5252e-11*a12 
+dwvth0_n_lvt = 0-1.48515e-10*a9-6.539e-10*a10+4.7373e-10*a11+3.3967e-10*a12 
+dpvth0_n_lvt = 0-1.98e-17*a9-8.786e-18*a10+2.9e-17*a11+2.8e-17*a12 
+du0_n_lvt = 0+4.8e-5*a9+3e-6*a10-9.86e-5*a11+2.8e-17*a12 
+dlu0_n_lvt = 0-4.2e-13*a9-1.18e-11*a10+9.27e-12*a11+1e-12*a12 
+dwu0_n_lvt = 0-3.13e-11*a9-1.8e-11*a10-6.02e-11*a11-3e-12*a12 
+dpu0_n_lvt = 0+2e-19*a9-2.7e-18*a10-1.1e-19*a11-2.3e-19*a12 
+dvsat_n_lvt = 0+0*a9+0*a10+0*a11+0*a12
+dpvsat_n_lvt = 0+0*a9+0*a10+0*a11+0*a12
+dcgso_n_lvt = -0.1312*(-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12) 
+dcgdo_n_lvt = -0.1312*(-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12) 
+dcgsl_n_lvt = -0.04725*(-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12) 
+dcgdl_n_lvt = -0.04725*(-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12) 
+dcj_n_lvt = 9.4e-6*a9-4.2e-6*a10-1.028e-5*a11+1.04e-6*a12 
+dcjsw_n_lvt = 8.2527e-8*(9.4e-6*a9-4.2e-6*a10-1.028e-5*a11+1.04e-6*a12) 
+dcjswg_n_lvt = 2.894e-7*(9.4e-6*a9-4.2e-6*a10-1.028e-5*a11+1.04e-6*a12) 
+tox_p_lvt = 2.41e-9-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12 
+dxl_p_lvt = 0-3.6e-11*a9-1.2e-9*a10-2.0075e-10*a11+3.3e-10*a12 
+dxw_p_lvt = 0+9.3985e-11*a9+3e-9*a10-7.3e-10*a11-2.8e-10*a12 
+dvth0_p_lvt = 0-4.728e-3*a9-4.07435e-3*a10+5.794423e-3*a11+2.881766e-3*a12 
+dlvth0_p_lvt = 0-1.27656e-10*a9+1.145204e-10*a10+2.665552e-10*a11-8.767273e-11*a12 
+dwvth0_p_lvt = 0-2.477e-10*a9-5.85438e-10*a10+2.69585e-10*a11+3.86431e-10*a12 
+dpvth0_p_lvt = 0-1.1323e-17*a9+4.873176e-18*a10+1.555013e-17*a11+3.233173e-17*a12 
+du0_p_lvt = 0-1.5072e-4*a9-4.7033e-4*a10-4.659791e-6*a11+3.233173e-17*a12 
+dlu0_p_lvt = 0+2.366e-11*a9-1.2567e-11*a10+8.999379e-13*a11+2.244082e-12*a12 
+dwu0_p_lvt = 0-6.386885e-11*a9-9.693e-11*a10-1.82348e-13*a11+2.722014e-11*a12 
+dpu0_p_lvt = 0-1.54e-18*a9-7.49e-18*a10-2.094039e-19*a11-6.471e-19*a12 
+dvsat_p_lvt = 0+0*a9+0*a10+0*a11+0*a12 
+dcgso_p_lvt = -0.0833*(-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12) 
+dcgdo_p_lvt = -0.0833*(-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12) 
+dcgsl_p_lvt = -0.090055*(-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12) 
+dcgdl_p_lvt = -0.090055*(-1.6e-13*a9-1.0803e-11*a10-2.55e-13*a11+7.7297e-12*a12) 
+dcj_p_lvt = 1.13e-5*a9-5.1e-6*a10-1.228e-5*a11+1.04e-6*a12 
+dcjsw_p_lvt = 8.5767e-8*(1.13e-5*a9-5.1e-6*a10-1.228e-5*a11+1.04e-6*a12) 
+dcjswg_p_lvt = 2.452e-7*(1.13e-5*a9-5.1e-6*a10-1.228e-5*a11+1.04e-6*a12)
include "gpdk045_mos.scs"   section = stat_mis_lvt 
include "gpdk045_mos.scs"   section = mos_lvt
endsection mc_lvt

section  tt_na
parameters
+tox_n_na = 2.41E-9            dxl_n_na = 0                  
+dxw_n_na = 0                  dvth0_n_na = 0                dlvth0_n_na = 0               
+dwvth0_n_na = 0               dpvth0_n_na = 0               dcj_n_na = 0                  
+dcjsw_n_na = 0                dcjswg_n_na = 0               dcgso_n_na = 0                
+dcgdo_n_na = 0                dcgsl_n_na = 0                dcgdl_n_na = 0                
+dvsat_n_na = 0                du0_n_na = 0                  dlu0_n_na = 0                 
+dwu0_n_na = 0                 dpu0_n_na = 0                 
include "gpdk045_mos.scs"   section = stat_mis_na
include "gpdk045_mos.scs"   section = mos_na
endsection  tt_na


section  ff_na
parameters
+tox_n_na = 2.37E-9            dxl_n_na = -1.5E-9            
+dxw_n_na = 3E-9               dvth0_n_na = -0.0334          dlvth0_n_na = -7.6E-9         
+dwvth0_n_na = -2.24E-9        dpvth0_n_na = -2.548E-15      dvsat_n_na = 0                
+du0_n_na = -3E-5              dlu0_n_na = -1.87E-10         dwu0_n_na = 3E-10             
+dpu0_n_na = -1.48E-16         dcj_n_na = -9.306E-6          
+dcjsw_n_na = -1.386E-11       dcjswg_n_na = -7.392E-12      dcgso_n_na = 5.517E-12        
+dcgdo_n_na = 5.517E-12        dcgsl_n_na = 0                dcgdl_n_na = 0                
include "gpdk045_mos.scs"   section = stat_mis_na                              
include "gpdk045_mos.scs"   section = mos_na
endsection  ff_na


section  ss_na
parameters
+tox_n_na = 2.45E-9            dxl_n_na = 1.5E-9             
+dxw_n_na = -3E-9              dvth0_n_na = 0.0341           dlvth0_n_na = 7.58E-9         
+dwvth0_n_na = 2.56E-9         dpvth0_n_na = -4.4E-16        dcj_n_na = 9.306E-6           
+dcjsw_n_na = 1.386E-11        dcjswg_n_na = 7.392E-12       dcgso_n_na = -5.517E-12       
+dcgdo_n_na = -5.517E-12       dcgsl_n_na = 0                dcgdl_n_na = 0                
+dvsat_n_na = 0                du0_n_na = -9E-5              dlu0_n_na = 1.47E-10          
+dwu0_n_na = -3.5E-10          dpu0_n_na = -9E-17            
include "gpdk045_mos.scs"   section = stat_mis_na
include "gpdk045_mos.scs"   section = mos_na
endsection  ss_na


section  fs_na
parameters
+tox_n_na = 2.41E-9            dxl_n_na = 0                  
+dxw_n_na = 0                  dvth0_n_na = -0.0157          dlvth0_n_na = -3.9E-9         
+dwvth0_n_na = -1.14E-9        dpvth0_n_na = -1.374E-15      dvsat_n_na = 0                
+du0_n_na = 1.864E-4           dlu0_n_na = -6.35E-11         dwu0_n_na = 2E-10             
+dpu0_n_na = -7.4E-17          dcj_n_na = -9.306E-6          
+dcjsw_n_na = -1.386E-11       dcjswg_n_na = -7.392E-12      dcgso_n_na = 0                
+dcgdo_n_na = 0                dcgsl_n_na = 0                dcgdl_n_na = 0                
include "gpdk045_mos.scs"   section = stat_mis_na                              
include "gpdk045_mos.scs"   section = mos_na
endsection  fs_na


section  sf_na
parameters
+tox_n_na = 2.41E-9            dxl_n_na = 0                  
+dxw_n_na = 0                  dvth0_n_na = 0.0171           dlvth0_n_na = 3.89E-9         
+dwvth0_n_na = 1.18E-9         dpvth0_n_na = 1.048E-15       dcj_n_na = 9.306E-6           
+dcjsw_n_na = 1.386E-11        dcjswg_n_na = 7.392E-12       dcgso_n_na = 0                
+dcgdo_n_na = 0                dcgsl_n_na = 0                dcgdl_n_na = 0                
+dvsat_n_na = 0                du0_n_na = -1.66E-4           dlu0_n_na = 6.35E-11          
+dwu0_n_na = -2.1E-10          dpu0_n_na = 1.71E-17          
include "gpdk045_mos.scs"   section = stat_mis_na
include "gpdk045_mos.scs"   section = mos_na
endsection  sf_na

section mc_na
parameters
+a17 = random17                  a18 = random18                  
+a19 = random19                  a20 = random20    
+tox_n_na = 2.41e-9-3.06e-12*a17-1.1903e-11*a18-7.3e-13*a19+4.8697e-12*a20 
+dxl_n_na = 0-1.55e-11*a17-4.48e-10*a18-3.934e-11*a19+2.122e-10*a20 
+dxw_n_na = 0+1.259399e-10*a17+8.1e-10*a18-5.095e-10*a19-1.15e-10*a20 
+dvth0_n_na = 0-6.652e-3*a17-4.9e-3*a18+5.9164e-3*a19+3.8623e-3*a20 
+dlvth0_n_na = 0-7.689e-10*a17-2.23e-9*a18+1.24158e-9*a19-7.5252e-11*a20 
+dwvth0_n_na = 0-2.9703e-10*a17-5.39e-11*a18+7.373e-10*a19+3.3967e-10*a20 
+dpvth0_n_na = 0-1.932e-16*a17+4.786e-18*a18+1.0749e-15*a19+2.8e-17*a20 
+du0_n_na = 0+1.29e-4*a17-1.917e-4*a18-4.86e-5*a19+2.8e-17*a20 
+dlu0_n_na = 0-2.1e-12*a17-4.851e-11*a18+8e-12*a19-1.1e-12*a20 
+dwu0_n_na = 0-1.03e-11*a17+1.79e-10*a18-6.08e-11*a19-3e-12*a20 
+dpu0_n_na = 0+5e-19*a17-1.124e-17*a18+7.251e-17*a19-3.4e-19*a20 
+dvsat_n_na = 0+0*a17+0*a18+0*a19+0*a20 
+dcgso_n_na = -0.261*(-3.06e-12*a17-1.1903e-11*a18-7.3e-13*a19+4.8697e-12*a20) 
+dcgdo_n_na = -0.261*(-3.06e-12*a17-1.1903e-11*a18-7.3e-13*a19+4.8697e-12*a20) 
+dcgsl_n_na = 0*(-3.06e-12*a17-1.1903e-11*a18-7.3e-13*a19+4.8697e-12*a20) 
+dcgdl_n_na = 0*(-3.06e-12*a17-1.1903e-11*a18-7.3e-13*a19+4.8697e-12*a20) 
+dcj_n_na = -1.2e-6*a17-1.01e-6*a18-2.85e-6*a19+5.7e-7*a20 
+dcjsw_n_na = 7.03e-7*(-1.2e-6*a17-1.01e-6*a18-2.85e-6*a19+5.7e-7*a20) 
+dcjswg_n_na = 1.55725e-6*(-1.2e-6*a17-1.01e-6*a18-2.85e-6*a19+5.7e-7*a20) 
include "gpdk045_mos.scs"   section = stat_mis_na
include "gpdk045_mos.scs"   section = mos_na
endsection mc_na

section  tt_18
parameters
+tox_n_18 = 3.62E-9            dxl_n_18 = 0                  
+dxw_n_18 = 0                  dvth0_n_18 = 0                dlvth0_n_18 = 0               
+dwvth0_n_18 = 0               dpvth0_n_18 = 0               du0_n_18 = 0                  
+dlu0_n_18 = 0                 dwu0_n_18 = 0                 dpu0_n_18 = 0                 
+dvsat_n_18 = 0                dcj_n_18 = 0                  dcjsw_n_18 = 0                
+dcjswg_n_18 = 0               dcgso_n_18 = 0                dcgdo_n_18 = 0                
+dcgsl_n_18 = 0                dcgdl_n_18 = 0                
+tox_p_18 = 3.62E-9            dxl_p_18 = 0                  dxw_p_18 = 0                  
+dvth0_p_18 = 0                dlvth0_p_18 = 0               dwvth0_p_18 = 0               
+dpvth0_p_18 = 0               du0_p_18 = 0                  dlu0_p_18 = 0                 
+dwu0_p_18 = 0                 dpu0_p_18 = 0                 dvsat_p_18 = 0                
+dcj_p_18 = 0                  dcjsw_p_18 = 0                dcjswg_p_18 = 0               
+dcgso_p_18 = 0                dcgdo_p_18 = 0                dcgsl_p_18 = 0                
+dcgdl_p_18 = 0                
include "gpdk045_mos.scs"   section = stat_mis_18
include "gpdk045_mos.scs"   section = mos18
endsection  tt_18


section  ff_18
parameters
+tox_n_18 = 3.49E-9            dxl_n_18 = -9E-9              
+dxw_n_18 = 9E-9               dvth0_n_18 = -0.0374          dlvth0_n_18 = -4E-9           
+dwvth0_n_18 = -6.6E-9         dpvth0_n_18 = -2.5E-16        du0_n_18 = 1.26E-3            
+dlu0_n_18 = -3.44E-10         dwu0_n_18 = 4.6E-11           dpu0_n_18 = 4E-18             
+dvsat_n_18 = 0                dcj_n_18 = -5.55E-5           dcjsw_n_18 = -6.732E-12       
+dcjswg_n_18 = -7.92E-12       dcgso_n_18 = 2.817E-12        dcgdo_n_18 = 2.817E-12        
+dcgsl_n_18 = 2.43E-12         dcgdl_n_18 = 2.43E-12         
+tox_p_18 = 3.49E-9            dxl_p_18 = -9E-9              dxw_p_18 = 9E-9               
+dvth0_p_18 = 0.03594          dlvth0_p_18 = 4.12E-9         dwvth0_p_18 = 2.8E-9          
+dpvth0_p_18 = 1.7232E-16      du0_p_18 = 1.44E-3            dlu0_p_18 = -2.28E-10         
+dwu0_p_18 = 2.4E-11           dpu0_p_18 = 8E-18             dvsat_p_18 = 0                
+dcj_p_18 = -6.402E-5          dcjsw_p_18 = -7.26E-12        dcjswg_p_18 = -1.518E-11      
+dcgso_p_18 = 1.98E-12         dcgdo_p_18 = 1.98E-12         dcgsl_p_18 = 9E-12            
+dcgdl_p_18 = 9E-12            
include "gpdk045_mos.scs"   section = stat_mis_18
include "gpdk045_mos.scs"   section = mos18
endsection  ff_18

section  ss_18
parameters
+tox_n_18 = 3.75E-9            dxl_n_18 = 9E-9               
+dxw_n_18 = -9E-9              dvth0_n_18 = 0.0346           dlvth0_n_18 = 4.08E-9         
+dwvth0_n_18 = 6.4E-9          dpvth0_n_18 = 2.214E-16       du0_n_18 = -1.802E-3          
+dlu0_n_18 = 2.62E-10          dwu0_n_18 = -2.2E-10          dpu0_n_18 = -7.3E-18          
+dvsat_n_18 = 0                dcj_n_18 = 5.55E-5            dcjsw_n_18 = 6.732E-12        
+dcjswg_n_18 = 7.92E-12        dcgso_n_18 = -2.817E-12       dcgdo_n_18 = -2.817E-12       
+dcgsl_n_18 = -2.43E-12        dcgdl_n_18 = -2.43E-12        
+tox_p_18 = 3.75E-9            dxl_p_18 = 9E-9               dxw_p_18 = -9E-9              
+dvth0_p_18 = -0.034           dlvth0_p_18 = -3.6E-9         dwvth0_p_18 = -2.4E-9         
+dpvth0_p_18 = -3.56E-16       du0_p_18 = -1.8E-3            dlu0_p_18 = 1.13E-10          
+dwu0_p_18 = -1.08E-10         dpu0_p_18 = 1E-17             dvsat_p_18 = 0                
+dcj_p_18 = 6.402E-5           dcjsw_p_18 = 7.26E-12         dcjswg_p_18 = 1.518E-11       
+dcgso_p_18 = -1.98E-12        dcgdo_p_18 = -1.98E-12        dcgsl_p_18 = -9E-12           
+dcgdl_p_18 = -9E-12           
include "gpdk045_mos.scs"   section = stat_mis_18
include "gpdk045_mos.scs"   section = mos18
endsection  ss_18


section  fs_18
parameters
+tox_n_18 = 3.62E-9            dxl_n_18 = 0                  
+dxw_n_18 = 0                  dvth0_n_18 = -0.0187          dlvth0_n_18 = -2E-9           
+dwvth0_n_18 = -2.9E-9         dpvth0_n_18 = -3.5E-17        du0_n_18 = 8E-4               
+dlu0_n_18 = 0                 dwu0_n_18 = 1.8E-10           dpu0_n_18 = 5.264E-17         
+dvsat_n_18 = 0                dcj_n_18 = -5.55E-5           dcjsw_n_18 = -6.732E-12       
+dcjswg_n_18 = -7.92E-12       dcgso_n_18 = 0                dcgdo_n_18 = 0                
+dcgsl_n_18 = 0                dcgdl_n_18 = 0                
+tox_p_18 = 3.62E-9            dxl_p_18 = 0                  dxw_p_18 = 0                  
+dvth0_p_18 = -0.017           dlvth0_p_18 = -1.2E-9         dwvth0_p_18 = -1.3E-9         
+dpvth0_p_18 = -1.86E-16       du0_p_18 = -8.6E-4            dlu0_p_18 = -7.3E-11          
+dwu0_p_18 = -1.28E-10         dpu0_p_18 = 3E-19             dvsat_p_18 = 0                
+dcj_p_18 = 6.402E-5           dcjsw_p_18 = 7.26E-12         dcjswg_p_18 = 1.518E-11       
+dcgso_p_18 = 0                dcgdo_p_18 = 0                dcgsl_p_18 = 0                
+dcgdl_p_18 = 0                
include "gpdk045_mos.scs"   section = stat_mis_18
include "gpdk045_mos.scs"   section = mos18
endsection  fs_18

section  sf_18
parameters
+tox_n_18 = 3.62E-9            dxl_n_18 = 0                  
+dxw_n_18 = 0                  dvth0_n_18 = 0.0166           dlvth0_n_18 = 1.44E-9         
+dwvth0_n_18 = 3.2E-9          dpvth0_n_18 = 1.507E-16       du0_n_18 = -9.72E-4           
+dlu0_n_18 = -9E-11            dwu0_n_18 = -2.08E-10         dpu0_n_18 = -1.7E-17          
+dvsat_n_18 = 0                dcj_n_18 = 5.55E-5            dcjsw_n_18 = 6.732E-12        
+dcjswg_n_18 = 7.92E-12        dcgso_n_18 = 0                dcgdo_n_18 = 0                
+dcgsl_n_18 = 0                dcgdl_n_18 = 0                
+tox_p_18 = 3.62E-9            dxl_p_18 = 0                  dxw_p_18 = 0                  
+dvth0_p_18 = 0.01797          dlvth0_p_18 = 2.22E-9         dwvth0_p_18 = 1.3E-9          
+dpvth0_p_18 = -4E-17          du0_p_18 = 7.4E-4             dlu0_p_18 = -2.9E-11          
+dwu0_p_18 = 1.158E-10         dpu0_p_18 = 3.744E-17         dvsat_p_18 = 0                
+dcj_p_18 = -6.402E-5          dcjsw_p_18 = -7.26E-12        dcjswg_p_18 = -1.518E-11      
+dcgso_p_18 = 0                dcgdo_p_18 = 0                dcgsl_p_18 = 0                
+dcgdl_p_18 = 0                
include "gpdk045_mos.scs"   section = stat_mis_18
include "gpdk045_mos.scs"   section = mos18
endsection  sf_18

section mc_18
parameters
+a13 = random13                  a14 = random14                  
+a15 = random15                  a16 = random16 
+tox_n_18 = 3.62e-9-4.216e-13*a13-4.118364e-11*a14-6.633e-13*a15+1.186255e-11*a16 
+dxl_n_18 = 0-5.0716e-10*a13-2.88e-9*a14-3.3158e-10*a15+5.5e-10*a16 
+dxw_n_18 = 0+2.81955e-10*a13+2e-9*a14-9.5e-10*a15-2.0444e-9*a16 
+dvth0_n_18 = 0-6.3e-3*a13-5.19e-3*a14+7.3164e-3*a15+3.8623e-3*a16 
+dlvth0_n_18 = 0-9.0589e-10*a13-1.046e-9*a14+2.4158e-10*a15-7.5252e-11*a16 
+dwvth0_n_18 = 0-7.9703e-10*a13-2.49e-10*a14+1.57373e-9*a15+1.33967e-9*a16 
+dpvth0_n_18 = 0-1.8e-18*a13+1.04786e-16*a14+2.49e-16*a15+2.8e-17*a16 
+du0_n_18 = 0+6.12e-4*a13+9.8e-5*a14-1.26e-4*a15+2.8e-17*a16 
+dlu0_n_18 = 0-9.834e-11*a13+3e-13*a14+8.8e-12*a15+2e-11*a16 
+dwu0_n_18 = 0+6.73e-11*a13+8e-12*a14-3.62e-11*a15-3e-12*a16 
+dpu0_n_18 = 0+5e-19*a13-9.14e-18*a14-2.93e-17*a15-9.4e-19*a16 
+dvsat_n_18 = 0+0*a13+0*a14+0*a15+0*a16 
+dcgso_n_18 = -0.02167*(-4.216e-13*a13-4.118364e-11*a14-6.633e-13*a15+1.186255e-11*a16) 
+dcgdo_n_18 = -0.02167*(-4.216e-13*a13-4.118364e-11*a14-6.633e-13*a15+1.186255e-11*a16) 
+dcgsl_n_18 = -0.01876*(-4.216e-13*a13-4.118364e-11*a14-6.633e-13*a15+1.186255e-11*a16) 
+dcgdl_n_18 = -0.01876*(-4.216e-13*a13-4.118364e-11*a14-6.633e-13*a15+1.186255e-11*a16) 
+dcj_n_18 = 1.1e-5*a13-5.1e-6*a14-1.293e-5*a15+1.34e-6*a16 
+dcjsw_n_18 = 1.2126e-7*(1.1e-5*a13-5.1e-6*a14-1.293e-5*a15+1.34e-6*a16) 
+dcjswg_n_18 = 1.426e-7*(1.1e-5*a13-5.1e-6*a14-1.293e-5*a15+1.34e-6*a16) 
+tox_p_18 = 3.62e-9-6.528e-13*a13-4.04702e-11*a14-5.1e-13*a15-1.038546e-11*a16 
+dxl_p_18 = 0-3.1e-11*a13-2.928e-9*a14-6.744e-11*a15+3.774e-10*a16 
+dxw_p_18 = 0+1.8797e-10*a13+2.5e-9*a14-1.437e-9*a15-2.3e-10*a16 
+dvth0_p_18 = 0+0.0114*a13-4.9519e-3*a14+5.64e-3*a15+3.8623e-3*a16 
+dlvth0_p_18 = 0-1.0589e-10*a13-1.35e-9*a14+2.4158e-10*a15-7.5252e-11*a16 
+dwvth0_p_18 = 0-1.703e-10*a13+3.39e-11*a14+1.63e-9*a15+3.3967e-10*a16 
+dpvth0_p_18 = 0-1.58e-17*a13+1.5986e-17*a14+2.949e-16*a15+2.8e-17*a16 
+du0_p_18 = 0+2.4e-4*a13-3.3e-4*a14+2.86e-5*a15+2.8e-17*a16 
+dlu0_p_18 = 0+9.1e-12*a13-2.7e-11*a14+1.88e-11*a15+4.8e-11*a16 
+dwu0_p_18 = 0+8.26e-11*a13-7.02e-11*a14+1.3e-10*a15-3e-12*a16 
+dpu0_p_18 = 0+8.7e-18*a13+8.4e-19*a14-1.41e-18*a15-4.94e-18*a16 
+dvsat_p_18 = 0+0*a13+0*a14+0*a15+0*a16 
+dcgso_p_18 = -0.01535*(-6.528e-13*a13-4.04702e-11*a14-5.1e-13*a15-1.038546e-11*a16) 
+dcgdo_p_18 = -0.01535*(-6.528e-13*a13-4.04702e-11*a14-5.1e-13*a15-1.038546e-11*a16) 
+dcgsl_p_18 = -0.0699*(-6.528e-13*a13-4.04702e-11*a14-5.1e-13*a15-1.038546e-11*a16) 
+dcgdl_p_18 = -0.0699*(-6.528e-13*a13-4.04702e-11*a14-5.1e-13*a15-1.038546e-11*a16) 
+dcj_p_18 = 1.3e-5*a13-5.3e-6*a14-1.493e-5*a15+3.7e-7*a16 
+dcjsw_p_18 = 1.1336e-7*(1.3e-5*a13-5.3e-6*a14-1.493e-5*a15+3.7e-7*a16) 
+dcjswg_p_18 = 2.371e-7*(1.3e-5*a13-5.3e-6*a14-1.493e-5*a15+3.7e-7*a16)
include "gpdk045_mos.scs"   section = stat_mis_18
include "gpdk045_mos.scs"   section = mos18
endsection mc_18

section  tt_na18
parameters
+tox_n_na18 = 3.62E-9          dxl_n_na18 = 0                
+dxw_n_na18 = 0                dvth0_n_na18 = 0              dlvth0_n_na18 = 0             
+dwvth0_n_na18 = 0             dpvth0_n_na18 = 0             du0_n_na18 = 0                
+dlu0_n_na18 = 0               dwu0_n_na18 = 0               dpu0_n_na18 = 0               
+dvsat_n_na18 = 0              dcj_n_na18 = 0                dcjsw_n_na18 = 0              
+dcjswg_n_na18 = 0             dcgso_n_na18 = 0              dcgdo_n_na18 = 0              
+dcgsl_n_na18 = 0              dcgdl_n_na18 = 0              
include "gpdk045_mos.scs"   section = stat_mis_18na        
include "gpdk045_mos.scs"   section = mos18_na
endsection  tt_na18

section  ff_na18
parameters
+tox_n_na18 = 3.49E-9          dxl_n_na18 = -6E-9            
+dxw_n_na18 = 1.2E-8           dvth0_n_na18 = -0.0484        dlvth0_n_na18 = -2E-8         
+dwvth0_n_na18 = -4E-9         dpvth0_n_na18 = -3.14E-15     du0_n_na18 = -8.8E-4          
+dlu0_n_na18 = 6E-10           dwu0_n_na18 = 5.2E-10         dpu0_n_na18 = -5.8E-16        
+dvsat_n_na18 = 0              dcj_n_na18 = -9.306E-6        dcjsw_n_na18 = -1.386E-11     
+dcjswg_n_na18 = -7.392E-12    dcgso_n_na18 = 5.517E-12      dcgdo_n_na18 = 5.517E-12      
+dcgsl_n_na18 = 0              dcgdl_n_na18 = 0              
include "gpdk045_mos.scs"   section = stat_mis_18na              
include "gpdk045_mos.scs"   section = mos18_na
endsection  ff_na18

section  ss_na18
parameters
+tox_n_na18 = 3.75E-9          dxl_n_na18 = 6E-9             
+dxw_n_na18 = -1.2E-8          dvth0_n_na18 = 0.0478         dlvth0_n_na18 = 2.08E-8       
+dwvth0_n_na18 = 5E-9          dpvth0_n_na18 = 1.76E-15      du0_n_na18 = 7.8E-4           
+dlu0_n_na18 = -9.4E-10        dwu0_n_na18 = -6.8E-10        dpu0_n_na18 = 5.84E-16        
+dvsat_n_na18 = 0              dcj_n_na18 = 9.306E-6         dcjsw_n_na18 = 1.386E-11      
+dcjswg_n_na18 = 7.392E-12     dcgso_n_na18 = -5.517E-12     dcgdo_n_na18 = -5.517E-12     
+dcgsl_n_na18 = 0              dcgdl_n_na18 = 0              
include "gpdk045_mos.scs"   section = stat_mis_18na          
include "gpdk045_mos.scs"   section = mos18_na
endsection  ss_na18

section  fs_na18
parameters
+tox_n_na18 = 3.63E-9          dxl_n_na18 = 0                
+dxw_n_na18 = 0                dvth0_n_na18 = -0.0242        dlvth0_n_na18 = -9E-9         
+dwvth0_n_na18 = -1.3E-9       dpvth0_n_na18 = -2.44E-15     du0_n_na18 = -1E-5            
+dlu0_n_na18 = 6.4E-10         dwu0_n_na18 = 5.6E-10         dpu0_n_na18 = -3.6E-16        
+dvsat_n_na18 = 0              dcj_n_na18 = -9.306E-6        dcjsw_n_na18 = -1.386E-11     
+dcjswg_n_na18 = -7.392E-12    dcgso_n_na18 = 0              dcgdo_n_na18 = 0              
+dcgsl_n_na18 = 0              dcgdl_n_na18 = 0              
include "gpdk045_mos.scs"   section = stat_mis_18na          
include "gpdk045_mos.scs"   section = mos18_na
endsection  fs_na18


section  sf_na18
parameters
+tox_n_na18 = 3.63E-9          dxl_n_na18 = 0                
+dxw_n_na18 = 0                dvth0_n_na18 = 0.0229         dlvth0_n_na18 = 1.1452E-8     
+dwvth0_n_na18 = 2.5E-9        dpvth0_n_na18 = 5.19552E-16   du0_n_na18 = 2E-5             
+dlu0_n_na18 = -5E-10          dwu0_n_na18 = -5.1E-10        dpu0_n_na18 = 2.086E-16       
+dvsat_n_na18 = 0              dcj_n_na18 = 9.306E-6         dcjsw_n_na18 = 1.386E-11      
+dcjswg_n_na18 = 7.392E-12     dcgso_n_na18 = 0              dcgdo_n_na18 = 0              
+dcgsl_n_na18 = 0              dcgdl_n_na18 = 0              
include "gpdk045_mos.scs"   section = stat_mis_18na          
include "gpdk045_mos.scs"   section = mos18_na
endsection  sf_na18


section mc_na18
parameters
+a21 = random21                  a22 = random22                  
+a23 = random23                  a24 = random24   
+tox_n_na18 = 3.62e-9-2.216e-13*a21-4.21836e-11*a22+2.12256e-13*a23+6.138147e-12*a24 
+dxl_n_na18 = 0-4.107996e-10*a21-1.8872e-9*a22-3.01843e-10*a23+4.51e-10*a24 
+dxw_n_na18 = 0+3.439851e-10*a21+2.58e-9*a22-1.357e-9*a23-2.780384e-9*a24 
+dvth0_n_na18 = 0-0.0115*a21-5.69e-3*a22+7.3164e-3*a23+2.23e-5*a24 
+dlvth0_n_na18 = 0-9.0589e-10*a21-9.9146e-9*a22+2.4158e-10*a23-7.5252e-11*a24 
+dwvth0_n_na18 = 0-7.9703e-10*a21-2.49e-10*a22+1.57373e-9*a23+1.33967e-9*a24 
+dpvth0_n_na18 = 0-1.8e-18*a21+2.4786e-17*a22+1.9149e-15*a23+2.8e-17*a24 
+du0_n_na18 = 0+1e-5*a21-8.01e-5*a22-6e-6*a23+2.8e-17*a24 
+dlu0_n_na18 = 0+6.134e-11*a21+6.13e-11*a22-1.608e-10*a23+2e-11*a24 
+dwu0_n_na18 = 0+6.73e-11*a21+8e-12*a22-2.12e-10*a23-3e-12*a24 
+dpu0_n_na18 = 0+5e-19*a21-9.14e-18*a22+2.4493e-16*a23-9.4e-19*a24 
+dvsat_n_na18 = 0+0*a21+0*a22+0*a23+0*a24 
+dcgso_n_na18 = -0.042405*(-2.216e-13*a21-4.21836e-11*a22+2.12256e-13*a23+6.138147e-12*a24) 
+dcgdo_n_na18 = -0.042405*(-2.216e-13*a21-4.21836e-11*a22+2.12256e-13*a23+6.138147e-12*a24) 
+dcgsl_n_na18 = 0*(-2.216e-13*a21-4.21836e-11*a22+2.12256e-13*a23+6.138147e-12*a24) 
+dcgdl_n_na18 = 0*(-2.216e-13*a21-4.21836e-11*a22+2.12256e-13*a23+6.138147e-12*a24) 
+dcj_n_na18 = -2.217e-6*a21-9.82e-7*a22-2.6548e-6*a23+6.7e-7*a24 
+dcjsw_n_na18 = 1.489316e-6*(-2.217e-6*a21-9.82e-7*a22-2.6548e-6*a23+6.7e-7*a24) 
+dcjswg_n_na18 = 7.943e-7*(-2.217e-6*a21-9.82e-7*a22-2.6548e-6*a23+6.7e-7*a24) 
include "gpdk045_mos.scs"   section = stat_mis_18na
include "gpdk045_mos.scs"   section = mos18_na
endsection mc_na18

section  mos
//  ***********************
//     Mismatch   model   * 
//  ***********************
inline subckt gpdk045_nmos1v ( d g s b ) 
parameters
+l=1e-6 w=1e-6 multi=1 nf=1 factor=1
+dmcg=4E-8 	
+xw=0+dxw_n
+ad=2*dmcg/factor*(w/nf+xw/factor) 
+as=2*dmcg/factor*(w/nf+xw/factor)
+pd=4*dmcg/factor+2*(w/nf+xw/factor) 
+ps=4*dmcg/factor+2*(w/nf+xw/factor)
+nrd=dmcg/factor/(w/nf+xw/factor)
+nrs=dmcg/factor/(w/nf+xw/factor)
+sa=6.1E-7/factor 
+sb=6.1E-7/factor 
+sd=2*dmcg/factor
+sca=1E-6/factor
+scb=1E-6/factor 
+scc=1E-6/factor
+misa1=rn1  misa2=rn2
+fac1=0.314*misa1+0.6132*misa2
+fac2=0.314*misa1-0.6132*misa2
+lef=l*factor
+wef=w/nf*factor
+geo_fac =1/sqrt(multi*nf*lef*wef*1e12)
+vthmis_n= 0.001364*geo_fac*fac1 
+dlmis_n= 0.001015*geo_fac*lef*fac2 
+dwmis_n= -0.001015*geo_fac*wef*fac2 
+toxmis_n= 0.001015*geo_fac*tox_n*fac2 
gpdk045_nmos1v ( d n1 s b ) nch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
//********include rg model ***************//
include "gpdk045_mos.scs"   section = res_rg
xrg ( g n1 ) ressnpoly_rg  ll=(w/3/nf/nf)*factor+5e-9 ww=l*factor  mf =multi
model nch bsim4 {
1:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                            
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n+dlmis_n)           lmax = 1.1E-5-(dxl_n+dlmis_n)           wmin = 2.0E-6-(dxw_n+dwmis_n)           
+wmax = 1.1E-5-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+(dxl_n+dlmis_n)                
+xw = 0.0+(dxw_n+dwmis_n)                
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.34925+dvth0_n+vthmis_n        lvth0 = 0.0+dlvth0_n          wvth0 = 0.0+dwvth0_n          
+pvth0 = 0.0+dpvth0_n          phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.0152801+du0_n          lu0 = -2.636545E-10+dlu0_n    wu0 = -3.215249E-10+dwu0_n    
+pu0 = 7.659855E-16+dpu0_n     ua = -1.9203E-9               lua = -9.059977E-18           
+wua = 1.401586E-17            pua = -4.284537E-24           ub = 2.276039E-18             
+lub = -2.737235E-26           wub = -4.319124E-26           pub = 9.846961E-32            
+uc = 7.443076E-11             luc = -1.669235E-17           wuc = -1.649254E-17           
+puc = 3.331794E-23            ud = 0                        vsat = 137107.0+dvsat_n       
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.930529                 la0 = -2.066163E-6            ags = 1.062652                
+lags = 8.605063E-7            b0 = 0                        b1 = 0                        
+keta = -6.63214E-2            lketa = 4.616804E-8           wketa = 7.781602E-10          
+pketa = -7.780046E-15         a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.15529               lvoff = 2.424242E-9           wvoff = 3.082726E-9           
+pvoff = -4.838786E-15         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.980741            lnfactor = 2.278475E-7        wnfactor = 2.101514E-7        
+pnfactor = -4.547836E-13      eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.652665E-3         
+lpdiblc2 = -1.102969E-9       wpdiblc2 = 2.236938E-11       ppdiblc2 = -2.236491E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
2:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n+dlmis_n)           lmax = 2.0E-6-(dxl_n+dlmis_n)           wmin = 2.0E-6-(dxw_n+dwmis_n)           
+wmax = 1.1E-5-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.348827+dvth0_n+vthmis_n       lvth0 = 8.442663E-10+dlvth0_n wvth0 = -3.248163E-9+dwvth0_n 
+pvth0 = 6.48983E-15+dpvth0_n  phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.53763E-2+du0_n         lu0 = -4.559811E-10+dlu0_n    wu0 = -3.06025E-10+dwu0_n     
+pu0 = 7.350168E-16+dpu0_n     ua = -1.918445E-9             lua = -1.27667E-17            
+wua = 7.107477E-18            pua = 9.518418E-24            ub = 2.275016E-18             
+lub = -2.532801E-26           wub = -2.188103E-27           pub = 1.654534E-32            
+uc = 6.607623E-11             wuc = 1.831096E-19            ud = 0                        
+vsat = 1.37107E5+dvsat_n      lvsat = 0                     wvsat = 0                     
+pvsat = 0                     a0 = 0.230932                 la0 = 1.329631E-6             
+wa0 = 3.747559E-7             pa0 = -7.487623E-13           ags = 0.164079                
+lags = 2.655856E-6            wags = 1.170882E-7            pags = -2.339422E-13          
+b0 = 0                        b1 = 0                        keta = -2.29457E-2            
+lketa = -4.049659E-8          wketa = -6.200143E-9          pketa = 6.162604E-15          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.156085              lvoff = 4.011719E-9           wvoff = 3.69253E-9            
+pvoff = -6.057175E-15         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.963931            lnfactor = 2.614339E-7        wnfactor = 7.362414E-9        
+pnfactor = -4.961115E-14      eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.076934E-3         
+lpdiblc2 = 4.734049E-11       wpdiblc2 = 1.472775E-10       ppdiblc2 = -4.732155E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
3:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_n+dlmis_n)           lmax = 1.0E-6-(dxl_n+dlmis_n)           wmin = 2.0E-6-(dxw_n+dwmis_n)           
+wmax = 1.1E-5-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.352645+dvth0_n+vthmis_n       lvth0 = -2.965664E-9+dlvth0_n wvth0 = 3.458363E-9+dwvth0_n  
+pvth0 = -2.032828E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.49678E-2+du0_n         lu0 = -4.831396E-11+dlu0_n    wu0 = 4.562986E-10+dwu0_n     
+pu0 = -2.57822E-17+dpu0_n     ua = -1.918037E-9             lua = -1.317425E-17           
+wua = -2.477865E-17           pua = 4.134077E-23            ub = 2.222816E-18             
+lub = 2.67682E-26             wub = 7.98867E-26             pub = -6.536532E-32           
+uc = 6.607623E-11             wuc = 1.831096E-19            ud = 0                        
+vsat = 1.37107E5+dvsat_n      lvsat = 0                     wvsat = 0                     
+pvsat = 0                     a0 = 1.426295                 la0 = 1.366587E-7             
+wa0 = -6.463353E-7            pa0 = 2.702867E-13            ags = 1.185611                
+lags = 1.636367E-6            wags = -2.593172E-7           pags = 1.417104E-13           
+b0 = 0                        b1 = 0                        keta = -6.35361E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.15272               lvoff = 6.530101E-10          wvoff = -3.353006E-9          
+pvoff = 9.742698E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.07151             lnfactor = 1.540699E-7        wnfactor = -9.169333E-8       
+pnfactor = 4.924649E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.15239E-3          
+lpdiblc2 = -2.79643E-11       wpdiblc2 = -6.069777E-10      ppdiblc2 = 2.795311E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
4:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_n+dlmis_n)           lmax = 5.0E-7-(dxl_n+dlmis_n)           wmin = 2.0E-6-(dxw_n+dwmis_n)           
+wmax = 1.1E-5-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.346512+dvth0_n+vthmis_n       lvth0 = 8.869664E-11+dlvth0_n wvth0 = 3.006781E-9+dwvth0_n  
+pvth0 = 2.160485E-17+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.49887E-2+du0_n         lu0 = -5.868444E-11+dlu0_n    wu0 = 4.724126E-10+dwu0_n     
+pu0 = -3.380697E-17+dpu0_n    ua = -1.943415E-9             lua = -5.355717E-19           
+wua = 6.168421E-17            pua = -1.717735E-24           ub = 2.268086E-18             
+lub = 4.223629E-27            wub = -5.176552E-26           pub = 1.974863E-34            
+uc = 6.095064E-11             luc = 2.552546E-18            wuc = 2.858476E-18            
+puc = -1.332332E-24           ud = 0                        vsat = 1.371068E5+dvsat_n     
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.117139                 la0 = -2.073816E-7            wa0 = -1.289706E-7            
+pa0 = 1.263912E-14            ags = 4.142833                lags = 1.636699E-7            
+wags = 2.338671E-8            pags = 9.238341E-16           b0 = 0                        
+b1 = 0                        keta = -6.84235E-2            lketa = 2.4402E-9             
+wketa = -2.518942E-11         a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.149693              lvoff = -8.543634E-10         wvoff = -1.512737E-9          
+pvoff = 5.78157E-17           voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.279392            lnfactor = 5.054459E-8        wnfactor = 6.666043E-9        
+pnfactor = 2.635179E-16       eta0 = 3.453491E-3            leta0 = -2.4402E-10           
+etab = -1.49631E-2            letab = -4.846381E-10         wetab = -2.347268E-8          
+petab = 1.168939E-14          dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 5.130311E-4         lpdiblc1 = -2.988006E-11      
+wpdiblc1 = -5.997613E-10      ppdiblc1 = 2.986811E-16       pdiblc2 = 8.131707E-3         
+lpdiblc2 = -1.766403E-11      wpdiblc2 = 8.259697E-10       ppdiblc2 = -4.340767E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
5:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_n+dlmis_n)           lmax = 1.0E-7-(dxl_n+dlmis_n)           wmin = 2.0E-6-(dxw_n+dwmis_n)           
+wmax = 1.1E-5-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.339782+dvth0_n+vthmis_n       lvth0 = 7.482256E-10+dlvth0_n wvth0 = -2.878078E-10+dwvth0_n 
+pvth0 = 3.444745E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -3.244617E-3             lk2 = -8.712575E-10           wk2 = -6.880378E-9            
+pk2 = 6.74277E-16             k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.46581E-2+du0_n         lu0 = -2.628521E-11+dlu0_n    wu0 = 1.408238E-10+dwu0_n     
+pu0 = -1.311271E-18+dpu0_n    ua = -2.013531E-9             lua = 6.335764E-18            
+wua = 3.038181E-17            pua = 1.349901E-24            ub = 2.31846E-18              
+lub = -7.130189E-28           wub = -8.336451E-27           pub = -4.058562E-33           
+uc = 8.699702E-11             wuc = -1.073675E-17           ud = 0                        
+vsat = 1.37107E5+dvsat_n      lvsat = 0                     wvsat = 0                     
+pvsat = 0                     a0 = 1E-3                     ags = 5.812934                
+wags = 3.281358E-8            b0 = 0                        b1 = 0                        
+keta = -0.036288              lketa = -7.09079E-10          wketa = -7.235125E-8          
+pketa = 7.087954E-15          a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.157109              lvoff = -1.275907E-10         wvoff = -1.689437E-9          
+pvoff = 7.513231E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.545726            lnfactor = 1.224439E-7        wnfactor = 2.845656E-9        
+pnfactor = 6.379158E-16       eta0 = 9.63491E-4             etab = -2.30596E-2            
+letab = 3.088173E-10          wetab = 2.105913E-7           petab = -1.124888E-14         
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = -5.88954E-3         lpdiblc1 = 5.975719E-10       
+wpdiblc1 = 1.877094E-8        ppdiblc1 = -1.599648E-15      pdiblc2 = 4.317518E-3         
+lpdiblc2 = 3.561265E-10       wpdiblc2 = 6.516453E-9        ppdiblc2 = -9.91744E-16       
+pdiblcb = 1                   drout = 0.752025              ldrout = -1.881841E-8         
+wdrout = -3.832811E-7         pdrout = 3.756155E-14         pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
6:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_n+dlmis_n)           wmin = 2.0E-6-(dxw_n+dwmis_n)           
+wmax = 1.1E-5-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.344879+dvth0_n+vthmis_n       lvth0 = 4.526312E-10+dlvth0_n wvth0 = 4.5947E-9+dwvth0_n    
+pvth0 = 6.12891E-17+dpvth0_n  phin = 0                      k1 = 0.30264                  
+k2 = -1.64348E-2              lk2 = -1.062293E-10           wk2 = -1.356298E-8            
+pk2 = 1.061868E-15            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.014758+du0_n           lu0 = -3.207916E-11+dlu0_n    wu0 = 8.87942E-9+dwu0_n       
+pu0 = -5.081499E-16+dpu0_n    ua = -2.01495E-9              lua = 6.41809E-18             
+wua = 8.840299E-16            pua = -4.816169E-23           ub = 2.3344E-18               
+lub = -1.637544E-27           wub = -2.323731E-25           pub = 8.935566E-33            
+uc = 8.699702E-11             wuc = -1.073675E-17           ud = 0                        
+vsat = 1.143112E5+dvsat_n     lvsat = 1.322158E-3           wvsat = 1.89544E-2            
+pvsat = -1.099356E-9          a0 = 1E-3                     ags = 5.812934                
+lags = 0                      wags = 3.281358E-8            pags = 0                      
+b0 = 0                        b1 = 0                        keta = -4.85135E-2            
+wketa = 4.985485E-8           a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.158578              lvoff = -4.238022E-11         wvoff = 2.690779E-9           
+pvoff = -1.789202E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.2338              lnfactor = 1.405356E-7        wnfactor = 1.220565E-9        
+pnfactor = 7.321712E-16       eta0 = 9.63491E-4             etab = -1.33266E-2            
+letab = -2.556967E-10         wetab = 4.495715E-8           petab = -1.642097E-15         
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 5.91146E-3          lpdiblc1 = -8.688609E-11      
+wpdiblc1 = -3.226781E-8       ppdiblc1 = 1.3606E-15         pdiblc2 = 7.963446E-3         
+lpdiblc2 = 1.446627E-10       wpdiblc2 = -1.146998E-8       ppdiblc2 = 5.146883E-17       
+pdiblcb = 1                   drout = 0.587767              ldrout = -9.291467E-9         
+wdrout = 2.01152E-7           pdrout = 3.664429E-15         pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
7:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n+dlmis_n)           lmax = 1.1E-5-(dxl_n+dlmis_n)           wmin = 1.0E-6-(dxw_n+dwmis_n)           
+wmax = 2.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.34925+dvth0_n+vthmis_n        lvth0 = 0+dlvth0_n            wvth0 = 0+dwvth0_n            
+pvth0 = 0+dpvth0_n            phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.52058E-2+du0_n         lu0 = 8.653106E-11+dlu0_n     wu0 = -1.732986E-10+dwu0_n    
+pu0 = 6.701504E-17+dpu0_n     ua = -1.912987E-9             lua = -1.411386E-17           
+wua = -5.804167E-19           pua = 5.803006E-24            ub = 2.253887E-18             
+lub = 2.709183E-26            wub = 1.024294E-27            pub = -1.024089E-32           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.930672                 la0 = -2.067598E-6            wa0 = -2.864845E-10           
+pa0 = 2.864272E-15            ags = 1.062652                lags = 8.605063E-7            
+b0 = 0                        b1 = 0                        keta = -6.58719E-2            
+lketa = 4.167334E-8           wketa = -1.191617E-10         pketa = 1.191378E-15          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.153746              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.086027            eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.662305E-3         
+lpdiblc2 = -1.199355E-9       wpdiblc2 = 3.127001E-12       ppdiblc2 = -3.126376E-17      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
8:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n+dlmis_n)           lmax = 2.0E-6-(dxl_n+dlmis_n)           wmin = 1.0E-6-(dxw_n+dwmis_n)           
+wmax = 2.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.347201+dvth0_n+vthmis_n       lvth0 = 4.093698E-9+dlvth0_n  wvth0 = 0+dwvth0_n            
+pvth0 = 3.964112E-18+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.52757E-2+du0_n         lu0 = -5.317929E-11+dlu0_n    wu0 = -1.052352E-10+dwu0_n    
+pu0 = -6.897555E-17+dpu0_n    ua = -1.911737E-9             lua = -1.661135E-17           
+wua = -6.280791E-18           pua = 1.719235E-23            ub = 2.273523E-18             
+lub = -1.214122E-26           wub = 7.913656E-28            pub = -9.7755E-33             
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.572041                 la0 = 6.469475E-7             wa0 = -3.060974E-7            
+pa0 = 6.138744E-13            ags = 0.261003                lags = 2.462202E-6            
+wags = -7.637165E-8           pags = 1.525906E-13           b0 = 0                        
+b1 = 0                        keta = -2.75228E-2            lketa = -3.494802E-8          
+wketa = 2.935746E-9           pketa = -4.912327E-15         a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.15424               lvoff = 9.869921E-10          wvoff = 9.9202E-12            
+pvoff = -1.982056E-17         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.980141            lnfactor = 2.115606E-7        wnfactor = -2.499295E-8       
+pnfactor = 4.993592E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.322699E-3         
+lpdiblc2 = -5.208203E-10      wpdiblc2 = -3.432679E-10      ppdiblc2 = 6.608333E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
9:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_n+dlmis_n)           lmax = 1.0E-6-(dxl_n+dlmis_n)           wmin = 1.0E-6-(dxw_n+dwmis_n)           
+wmax = 2.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.354115+dvth0_n+vthmis_n       lvth0 = -2.80614E-9+dlvth0_n  wvth0 = 5.247249E-10+dwvth0_n 
+pvth0 = -5.216914E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.015143+du0_n           lu0 = 7.925464E-11+dlu0_n     wu0 = 1.066221E-10+dwu0_n     
+pu0 = -2.804091E-16+dpu0_n    ua = -1.959977E-9             lua = 3.153198E-17            
+wua = 5.893485E-17            pua = -4.789285E-23           ub = 2.285082E-18             
+lub = -2.367677E-26           wub = -4.439737E-26           pub = 3.532286E-32            
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.852892                 la0 = 3.666576E-7             wa0 = 4.981766E-7             
+pa0 = -1.88791E-13            ags = 0.896741                lags = 1.827735E-6            
+wags = 3.172668E-7            pags = -2.402606E-13          b0 = 0                        
+b1 = 0                        keta = -6.25409E-2            wketa = -1.986426E-9          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.15453               lvoff = 1.276756E-9           wvoff = 2.613287E-10          
+pvoff = -2.707262E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.9986              lnfactor = 1.931386E-7        wnfactor = 5.383515E-8        
+pnfactor = -2.873453E-14      eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 7.576672E-3         
+lpdiblc2 = 2.237144E-10       wpdiblc2 = 5.421558E-10       ppdiblc2 = -2.228195E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
10:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_n+dlmis_n)           lmax = 5.0E-7-(dxl_n+dlmis_n)           wmin = 1.0E-6-(dxw_n+dwmis_n)           
+wmax = 2.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.348623+dvth0_n+vthmis_n       lvth0 = -7.119331E-11+dlvth0_n wvth0 = -1.207173E-9+dwvth0_n 
+pvth0 = 3.407937E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.53686E-2+du0_n         lu0 = -3.306481E-11+dlu0_n    wu0 = -2.858787E-10+dwu0_n    
+pu0 = -8.494375E-17+dpu0_n    ua = -1.899401E-9             lua = 1.365183E-18            
+wua = -2.616799E-17           pua = -5.511642E-24           ub = 2.226137E-18             
+lub = 5.677783E-27            wub = 3.19638E-26             pub = -2.705005E-33           
+uc = 6.099261E-11             luc = 2.57733E-18             wuc = 2.774701E-18            
+puc = -1.381801E-24           ud = 0                        vsat = 1.371068E5+dvsat_n     
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.97825                  la0 = -1.937705E-7            wa0 = 1.482523E-7             
+pa0 = -1.452873E-14           ags = 4.231225                lags = 1.671619E-7            
+wags = -1.530432E-7           pags = -6.046239E-15          b0 = 0                        
+b1 = 0                        keta = -5.16684E-2            lketa = -5.414518E-9          
+wketa = -3.346839E-8          pketa = 1.567802E-14          a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.150353              lvoff = -8.036452E-10         wvoff = -1.951138E-10         
+pvoff = -4.341785E-17         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.284525            lnfactor = 5.074758E-8        wnfactor = -3.580258E-9       
+pnfactor = -1.416538E-16      eta0 = 3.941531E-3            leta0 = -4.870639E-10         
+weta0 = -9.741278E-10         peta0 = 4.851157E-16          etab = -0.026723              
+letab = 5.371771E-9           dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = -2.697E-5           lpdiblc1 = 2.390405E-10       
+wpdiblc1 = 4.78081E-10        ppdiblc1 = -2.380843E-16      pdiblc2 = 8.238968E-3         
+lpdiblc2 = -1.061089E-10      wpdiblc2 = 6.118768E-10       ppdiblc2 = -2.575406E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
11:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_n+dlmis_n)           lmax = 1.0E-7-(dxl_n+dlmis_n)           wmin = 1.0E-6-(dxw_n+dwmis_n)           
+wmax = 2.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.338826+dvth0_n+vthmis_n       lvth0 = 8.889634E-10+dlvth0_n wvth0 = 1.621724E-9+dwvth0_n  
+pvth0 = 6.356184E-17+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.270173E-3             lk2 = -1.064753E-9            wk2 = -1.082137E-8            
+pk2 = 1.060494E-15            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.43509E-2+du0_n         lu0 = 6.666684E-11+dlu0_n     wu0 = 7.539153E-10+dwu0_n     
+pu0 = -1.868436E-16+dpu0_n    ua = -2.031672E-9             lua = 1.432769E-17            
+wua = 6.659068E-17            pua = -1.460199E-23           ub = 2.303017E-18             
+lub = -1.856416E-27           wub = 2.248764E-26            pub = -1.776342E-33           
+uc = 1.007963E-10             luc = -1.323435E-18           wuc = -3.828017E-17           
+puc = 2.641576E-24            ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1E-3                     ags = 5.936959                wags = -2.147395E-7           
+b0 = 0                        b1 = 0                        keta = -0.164803              
+lketa = 5.672632E-9           wketa = 1.841638E-7           pketa = -5.649941E-15         
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.156994              lvoff = -1.527893E-10         wvoff = -1.918038E-9          
+pvoff = 1.254287E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.547918            lnfactor = 1.229351E-7        wnfactor = -1.529083E-9       
+pnfactor = -3.42669E-16       eta0 = -5.072269E-3           leta0 = 3.962885E-10          
+weta0 = 1.204738E-8           peta0 = -7.909918E-16         etab = 9.25777E-2             
+letab = -6.319699E-9          wetab = -2.022081E-8          petab = 1.98164E-15           
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 7.321613E-3         lpdiblc1 = -4.811206E-10      
+wpdiblc1 = -7.598517E-9       ppdiblc1 = 5.534222E-16       pdiblc2 = 7.799202E-3         
+lpdiblc2 = -6.301194E-11      wpdiblc2 = -4.329896E-10      ppdiblc2 = -1.551437E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
12:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_n+dlmis_n)           wmin = 1.0E-6-(dxw_n+dwmis_n)           
+wmax = 2.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.354254+dvth0_n+vthmis_n       lvth0 = -5.87053E-12+dlvth0_n wvth0 = -1.411788E-8+dwvth0_n 
+pvth0 = 9.764586E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -2.10085E-2              lk2 = 8.007246E-11            wk2 = -4.433707E-9            
+pk2 = 6.900097E-16            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 2.32553E-2+du0_n         lu0 = -4.497874E-10+dlu0_n    wu0 = -8.081245E-9+dwu0_n     
+pu0 = 3.255957E-16+dpu0_n     ua = -1.204502E-9             lua = -3.364816E-17           
+wua = -7.336254E-16           pua = 3.181054E-23            ub = 2.13422E-18              
+lub = 7.933776E-27            wub = 1.67185E-25             pub = -1.016879E-32           
+uc = 7.797849E-11             wuc = 7.26425E-18             ud = 0                        
+vsat = 1.238074E5+dvsat_n     lvsat = 7.71378E-4            wvsat = -2.190794E-6          
+pvsat = 1.27066E-13           a0 = 1E-3                     ags = 5.936959                
+wags = -2.147395E-7           b0 = 0                        b1 = 0                        
+keta = -6.69986E-2            wketa = 8.675105E-8           a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.156783              lvoff = -1.650571E-10         wvoff = -8.924204E-10         
+pvoff = 6.594289E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.234741            lnfactor = 1.410994E-7        wnfactor = -6.570393E-10      
+pnfactor = -3.932475E-16      eta0 = 1.760291E-3            weta0 = -1.590413E-9          
+etab = -1.13964E-2            letab = -2.891974E-10         wetab = 4.110453E-8           
+petab = -1.57523E-15          dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = -1.01684E-2         lpdiblc1 = 5.332986E-10       
+wpdiblc1 = -1.724596E-10      ppdiblc1 = 1.227109E-16       pdiblc2 = 2.88314E-3          
+lpdiblc2 = 2.221197E-10       wpdiblc2 = -1.329686E-9       ppdiblc2 = -1.031353E-16      
+pdiblcb = 1                   drout = 0.767707              ldrout = -1.204703E-8         
+wdrout = -1.580091E-7         pdrout = 9.164528E-15         pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
13:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n+dlmis_n)           lmax = 1.1E-5-(dxl_n+dlmis_n)           wmin = 5.0E-7-(dxw_n+dwmis_n)           
+wmax = 1.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.34925+dvth0_n+vthmis_n        lvth0 = 0+dlvth0_n            wvth0 = 0+dwvth0_n            
+pvth0 = 0+dpvth0_n            phin = 0                      k1 = 0.30264                  
+k2 = -1.37822E-2              wk2 = 1.640627E-9             k3 = -7.284535                
+k3b = 2.454986                w0 = 8.190018E-8              lpe0 = 6.610138E-8            
+lpeb = 2.000404E-8            dvtp0 = 2.36094E-6            dvtp1 = 4.5                   
+dvt0 = 0.236381               dvt1 = 0.537442               dvt2 = 5.56679E-2             
+dvt0w = 0                     dvt1w = 0                     dvt2w = 0                     
+vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.51313E-2+du0_n         lu0 = -5.040825E-10+dlu0_n    wu0 = -9.913281E-11+dwu0_n    
+pu0 = 6.552661E-16+dpu0_n     ua = -1.898517E-9             lua = -1.255994E-16           
+wua = -1.499256E-17           pua = 1.168426E-22            ub = 2.219652E-18             
+lub = 1.417534E-25            wub = 3.512221E-26            pub = -1.244438E-31           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.040554                 la0 = -3.166193E-6            wa0 = -1.097284E-7            
+pa0 = 1.097065E-12            ags = 1.062652                lags = 8.605063E-7            
+b0 = 0                        b1 = 0                        keta = -6.64279E-2            
+lketa = 4.723253E-8           wketa = 4.346448E-10          pketa = -4.345579E-15         
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.153675              lvoff = -7.08429E-10          wvoff = -7.057364E-11         
+pvoff = 7.055953E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.086027            eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.708636E-3         
+lpdiblc2 = -1.662569E-9       wpdiblc2 = -4.301834E-11      ppdiblc2 = 4.300973E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
14:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n+dlmis_n)           lmax = 2.0E-6-(dxl_n+dlmis_n)           wmin = 5.0E-7-(dxw_n+dwmis_n)           
+wmax = 1.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.346552+dvth0_n+vthmis_n       lvth0 = 5.391324E-9+dlvth0_n  wvth0 = 6.448806E-10+dwvth0_n 
+pvth0 = -1.288471E-15+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.57781E-2              lk2 = 3.987753E-9             wk2 = 3.628516E-9             
+pk2 = -3.971802E-15           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.49573E-2+du0_n         lu0 = -1.562565E-10+dlu0_n    wu0 = 2.119667E-10+dwu0_n     
+pu0 = 3.368939E-17+dpu0_n     ua = -1.971699E-9             lua = 2.061848E-17            
+wua = 5.344148E-17            pua = -1.988856E-23           ub = 2.318703E-18             
+lub = -5.615056E-26           wub = -4.420794E-26           pub = 3.405781E-32            
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = -0.40514                 la0 = 1.720302E-6             wa0 = 6.671745E-7             
+pa0 = -4.55187E-13            ags = 2.21022E-2              lags = 2.939525E-6            
+wags = 1.615732E-7            pags = -3.228232E-13          b0 = 0                        
+b1 = 0                        keta = -0.022828              lketa = -3.988008E-8          
+wketa = -1.74032E-9           a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.154994              lvoff = 1.926447E-9           wvoff = 7.608143E-10          
+pvoff = -9.555178E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.943029            lnfactor = 2.857106E-7        wnfactor = 1.197072E-8        
+pnfactor = -2.39175E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 7.830016E-3         
+lpdiblc2 = 9.291504E-11       wpdiblc2 = 1.474443E-10       ppdiblc2 = 4.955296E-17       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
15:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_n+dlmis_n)           lmax = 1.0E-6-(dxl_n+dlmis_n)           wmin = 5.0E-7-(dxw_n+dwmis_n)           
+wmax = 1.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.356799+dvth0_n+vthmis_n       lvth0 = -4.835634E-9+dlvth0_n wvth0 = -2.148863E-9+dwvth0_n 
+pvth0 = 1.499685E-15+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.17823E-2              wk2 = -3.512454E-10           k3 = -7.284535                
+k3b = 2.454986                w0 = 8.190018E-8              lpe0 = 6.610138E-8            
+lpeb = 2.000404E-8            dvtp0 = 2.36094E-6            dvtp1 = 4.5                   
+dvt0 = 0.236381               dvt1 = 0.537442               dvt2 = 5.56679E-2             
+dvt0w = 0                     dvt1w = 0                     dvt2w = 0                     
+vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.55148E-2+du0_n         lu0 = -7.126632E-10+dlu0_n    wu0 = -2.636362E-10+dwu0_n    
+pu0 = 5.08341E-16+dpu0_n      ua = -1.871537E-9             lua = -7.934329E-17           
+wua = -2.915118E-17           pua = 6.253891E-23            ub = 2.210337E-18             
+lub = 5.19993E-26             wub = 3.00489E-26             pub = -4.005052E-32           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.941253                 la0 = 3.766023E-7             wa0 = 4.101694E-7             
+pa0 = -1.986959E-13           ags = 1.534856                lags = 1.429796E-6            
+wags = -3.182958E-7           pags = 1.56086E-13            b0 = 0                        
+b1 = 0                        keta = -0.062788              wketa = -1.74032E-9           
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.15423               lvoff = 1.163697E-9           wvoff = -3.818151E-11         
+pvoff = -1.5812E-16           voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.067339            lnfactor = 1.61649E-7         wnfactor = -1.462909E-8       
+pnfactor = 2.629113E-15       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 7.664712E-3         
+lpdiblc2 = 2.578881E-10       wpdiblc2 = 4.544679E-10       ppdiblc2 = -2.568566E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
16:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_n+dlmis_n)           lmax = 5.0E-7-(dxl_n+dlmis_n)           wmin = 5.0E-7-(dxw_n+dwmis_n)           
+wmax = 1.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.347058+dvth0_n+vthmis_n       lvth0 = 1.546897E-11+dlvth0_n wvth0 = 3.515467E-10+dwvth0_n 
+pvth0 = 2.544806E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.17823E-2              wk2 = -3.512454E-10           k3 = -7.284535                
+k3b = 2.454986                w0 = 8.190018E-8              lpe0 = 6.610138E-8            
+lpeb = 2.000404E-8            dvtp0 = 2.36094E-6            dvtp1 = 4.5                   
+dvt0 = 0.236381               dvt1 = 0.537442               dvt2 = 5.56679E-2             
+dvt0w = 0                     dvt1w = 0                     dvt2w = 0                     
+vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.43396E-2+du0_n         lu0 = -1.27403E-10+dlu0_n     wu0 = 7.390222E-10+dwu0_n     
+pu0 = 9.017124E-18+dpu0_n     ua = -2.014187E-9             lua = -8.303839E-18           
+wua = 8.815847E-17            pua = 4.118704E-24            ub = 2.296589E-18             
+lub = 9.045685E-27            wub = -3.820628E-26           pub = -6.059435E-33           
+uc = 6.259793E-11             luc = 1.77788E-18             wuc = 1.175801E-18            
+puc = -5.855489E-25           ud = 0                        vsat = 1.371068E5+dvsat_n     
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.113121                 la0 = -2.069878E-7            wa0 = 1.392104E-8             
+pa0 = -1.364262E-15           ags = 4.082098                lags = 1.612703E-7            
+wags = -4.512233E-9           pags = -1.781726E-16          b0 = 0                        
+b1 = 0                        keta = -0.099233              lketa = 1.814964E-8           
+wketa = 1.390603E-8           pketa = -7.79188E-15          a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.150151              lvoff = -8.673291E-10         wvoff = -3.958748E-10         
+pvoff = 2.001126E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.289628            lnfactor = 5.094885E-8        wnfactor = -8.662758E-9       
+pnfactor = -3.421203E-16      eta0 = 2.963491E-3            etab = -0.026723              
+letab = 5.371771E-9           dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.873928E-3         
+lpdiblc2 = -3.443013E-10      wpdiblc2 = -2.054318E-11      ppdiblc2 = -2.030107E-17      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
17:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_n+dlmis_n)           lmax = 1.0E-7-(dxl_n+dlmis_n)           wmin = 5.0E-7-(dxw_n+dwmis_n)           
+wmax = 1.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.340007+dvth0_n+vthmis_n       lvth0 = 7.065178E-10+dlvth0_n wvth0 = 4.454542E-10+dwvth0_n 
+pvth0 = 2.452777E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -8.371754E-3             lk2 = -3.342378E-10           wk2 = -3.748193E-9            
+pk2 = 3.329009E-16            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.46604E-2+du0_n         lu0 = -1.588462E-10+dlu0_n    wu0 = 4.456518E-10+dwu0_n     
+pu0 = 3.776742E-17+dpu0_n     ua = -2.067541E-9             lua = -3.075097E-18           
+wua = 1.023168E-16            pua = 2.731189E-24            ub = 2.42677E-18              
+lub = -3.712065E-27           wub = -1.007708E-25           pub = 7.188447E-35            
+uc = 6.078779E-11             luc = 1.955274E-18            wuc = 1.568338E-18            
+puc = -6.240175E-25           ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1E-3                     ags = 5.727713                wags = -6.330321E-9           
+b0 = 0                        b1 = 0                        keta = 0.114735               
+lketa = -2.819264E-9          wketa = -9.425588E-8          pketa = 2.807987E-15          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.158952              lvoff = -4.866641E-12         wvoff = 3.181463E-11          
+pvoff = -2.19023E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.550091            lnfactor = 1.234235E-7        wnfactor = -3.694005E-9       
+pnfactor = -8.290581E-16      eta0 = 6.788326E-3            leta0 = -3.748338E-10         
+weta0 = 2.342248E-10          peta0 = -2.295403E-17         etab = 0.116107               
+letab = -8.625562E-9          wetab = -4.365591E-8          petab = 4.278279E-15          
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = -6.12381E-4         lpdiblc1 = 1.484522E-10       
+wpdiblc1 = 3.03741E-10        ppdiblc1 = -7.363231E-17      pdiblc2 = 2.757225E-3         
+lpdiblc2 = 2.551356E-10       wpdiblc2 = 4.58882E-9         ppdiblc2 = -4.720187E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
18:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_n+dlmis_n)           wmin = 5.0E-7-(dxw_n+dwmis_n)           
+wmax = 1.0E-6-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.346779+dvth0_n+vthmis_n       lvth0 = 3.136908E-10+dlvth0_n wvth0 = -6.673474E-9+dwvth0_n 
+pvth0 = 6.581755E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.64376E-2              lk2 = 1.335793E-10            wk2 = -8.9864E-9              
+pk2 = 6.367169E-16            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.52269E-2+du0_n         lu0 = -1.917E-10+dlu0_n       wu0 = -8.492135E-11+dwu0_n    
+pu0 = 6.854067E-17+dpu0_n     ua = -1.963803E-9             lua = -9.091916E-18           
+wua = 2.263858E-17            pua = 7.352525E-24            ub = 2.369009E-18             
+lub = -3.619039E-28           wub = -6.66643E-26            pub = -1.906291E-33           
+uc = 1.268636E-10             luc = -1.877124E-18           wuc = -4.142533E-17           
+puc = 1.869615E-24            ud = 0                        vsat = 1.207921E5+dvsat_n     
+lvsat = 9.462655E-4           wvsat = 3.003242E-3           pvsat = -1.74188E-10          
+a0 = 1E-3                     ags = 5.727713                wags = -6.330321E-9           
+b0 = 0                        b1 = 0                        keta = 6.61273E-2             
+wketa = -4.584231E-8          a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.157691              lvoff = -7.796959E-11         wvoff = 1.274561E-11          
+pvoff = -2.07963E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.23567             lnfactor = 1.416599E-7        wnfactor = -1.582728E-9       
+pnfactor = -9.515122E-16      eta0 = 0                      etab = -5.13546E-2            
+letab = 1.087207E-9           wetab = 8.090284E-8           petab = -2.946129E-15         
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = -1.16079E-2         lpdiblc1 = 7.861951E-10       
+wpdiblc1 = 1.261355E-9        ppdiblc1 = -1.291739E-16      pdiblc2 = 3.083844E-3         
+lpdiblc2 = 2.361917E-10       wpdiblc2 = -1.529587E-9       ppdiblc2 = -1.171511E-16      
+pdiblcb = 1                   drout = 0.492949              ldrout = 3.888975E-9          
+wdrout = 1.156505E-7          pdrout = -6.707731E-15        pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
19:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n+dlmis_n)           lmax = 1.1E-5-(dxl_n+dlmis_n)           wmin = 3.0E-7-(dxw_n+dwmis_n)           
+wmax = 5.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.34925+dvth0_n+vthmis_n        lvth0 = 0+dlvth0_n            wvth0 = 0+dwvth0_n            
+pvth0 = 0+dpvth0_n            phin = 0                      k1 = 0.30264                  
+k2 = -1.04745E-2              k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.49116E-2+du0_n         lu0 = 2.28083E-9+dlu0_n       wu0 = 9.85574E-12+dwu0_n      
+pu0 = -7.260506E-16+dpu0_n    ua = -1.946422E-9             lua = 2.867106E-16            
+wua = 8.768067E-18            pua = -8.766314E-23           ub = 2.288411E-18             
+lub = -2.348348E-25           wub = 1.017804E-27            pub = 6.234393E-32            
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.812026                 la0 = -8.813739E-7            wa0 = 3.621262E-9             
+pa0 = -3.620538E-14           ags = 1.130666                lags = 9.155813E-7            
+wags = -3.373463E-8           pags = -2.731717E-14          b0 = 0                        
+b1 = 0                        keta = -6.38539E-2            lketa = 2.149758E-8           
+wketa = -8.420645E-10         pketa = 8.41896E-15           a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.154478              lvoff = 1.771073E-9           wvoff = 3.277142E-10          
+pvoff = -5.242375E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.086027            eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.645462E-3         
+lpdiblc2 = -1.030951E-9       wpdiblc2 = -1.168385E-11      ppdiblc2 = 1.168151E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
20:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n+dlmis_n)           lmax = 2.0E-6-(dxl_n+dlmis_n)           wmin = 3.0E-7-(dxw_n+dwmis_n)           
+wmax = 5.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.347226+dvth0_n+vthmis_n       lvth0 = 4.044877E-9+dlvth0_n  wvth0 = 3.106274E-10+dwvth0_n 
+pvth0 = -6.206336E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -5.484819E-3             lk2 = -9.969382E-9            wk2 = -1.476945E-9            
+pk2 = 2.950937E-15            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.016115+du0_n           lu0 = -1.234528E-10+dlu0_n    wu0 = -3.62251E-10+dwu0_n     
+pu0 = 1.741873E-17+dpu0_n     ua = -1.781269E-9             lua = -4.32655E-17            
+wua = -4.101223E-17           pua = 1.179789E-23            ub = 2.155343E-18             
+lub = 3.103564E-26            wub = 3.681885E-26            pub = -9.186548E-33           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.880942                 la0 = 9.789311E-7             wa0 = 2.927767E-8             
+pa0 = -8.746689E-14           ags = 0.478301                lags = 2.219005E-6            
+wags = -6.470165E-8           pags = 3.455495E-14           b0 = 0                        
+b1 = 0                        keta = -3.31343E-2            lketa = -3.988008E-8          
+wketa = 3.371629E-9           a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.152723              lvoff = -1.735262E-9          wvoff = -3.654426E-10         
+pvoff = 8.6069E-16            voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.988391            lnfactor = 1.950763E-7        wnfactor = -1.05291E-8        
+pnfactor = 2.103714E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 7.890134E-3         
+lpdiblc2 = 4.781941E-10       wpdiblc2 = 1.176257E-10       ppdiblc2 = -1.415454E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
21:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_n+dlmis_n)           lmax = 1.0E-6-(dxl_n+dlmis_n)           wmin = 3.0E-7-(dxw_n+dwmis_n)           
+wmax = 5.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.355781+dvth0_n+vthmis_n       lvth0 = -4.49395E-9+dlvth0_n  wvth0 = -1.644125E-9+dwvth0_n 
+pvth0 = 1.330209E-15+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.90759E-2              lk2 = 3.594564E-9             wk2 = 3.266382E-9             
+pk2 = -1.782904E-15           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.59989E-2+du0_n         lu0 = -7.606149E-12+dlu0_n    wu0 = -5.03748E-10+dwu0_n     
+pu0 = 1.586327E-16+dpu0_n     ua = -1.830042E-9             lua = 5.410306E-18            
+wua = -4.97329E-17            pua = 2.050113E-23            ub = 2.168205E-18             
+lub = 1.819905E-26            wub = 5.094614E-26            pub = -2.328559E-32           
+uc = 6.24374E-11              luc = 3.723111E-18            wuc = 1.850364E-18            
+puc = -1.846663E-24           ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.022314                 la0 = -1.601579E-7            wa0 = -1.26037E-7             
+pa0 = 6.753712E-14            ags = 0.973715                lags = 1.724582E-6            
+wags = -3.996983E-8           pags = 9.872589E-15           b0 = 0                        
+b1 = 0                        keta = -7.30943E-2            wketa = 3.371629E-9           
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.157082              lvoff = 2.614678E-9           wvoff = 1.376538E-9           
+pvoff = -8.778067E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.003111            lnfactor = 1.803855E-7        wnfactor = 1.722773E-8        
+pnfactor = -6.66418E-15       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 9.015298E-3         
+lpdiblc2 = -6.447203E-10      wpdiblc2 = -2.15423E-10       ppdiblc2 = 1.908372E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
22:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_n+dlmis_n)           lmax = 5.0E-7-(dxl_n+dlmis_n)           wmin = 3.0E-7-(dxw_n+dwmis_n)           
+wmax = 5.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.346358+dvth0_n+vthmis_n       lvth0 = 1.98848E-10+dlvth0_n  wvth0 = 6.985727E-10+dwvth0_n 
+pvth0 = 1.635459E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.18579E-2              wk2 = -3.137458E-10           k3 = -7.284535                
+k3b = 2.454986                w0 = 8.190018E-8              lpe0 = 6.610138E-8            
+lpeb = 2.000404E-8            dvtp0 = 2.36094E-6            dvtp1 = 4.5                   
+dvt0 = 0.236381               dvt1 = 0.537442               dvt2 = 5.56679E-2             
+dvt0w = 0                     dvt1w = 0                     dvt2w = 0                     
+vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 0.016219+du0_n           lu0 = -1.172228E-10+dlu0_n    wu0 = -1.931757E-10+dwu0_n    
+pu0 = 3.967734E-18+dpu0_n     ua = -1.804614E-9             lua = -7.252967E-18           
+wua = -1.578982E-17           pua = 3.597472E-24            ub = 2.188423E-18             
+lub = 8.130537E-27            wub = 1.544399E-26            pub = -5.605521E-33           
+uc = 6.976073E-11             luc = 7.609056E-20            wuc = -2.376949E-18           
+puc = 2.585386E-25            ud = 0                        vsat = 1.371068E5+dvsat_n     
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.117141                 la0 = -2.073819E-7            wa0 = 1.192678E-8             
+pa0 = -1.168825E-15           ags = 4.110631                lags = 1.623977E-7            
+wags = -1.866466E-8           pags = -7.373895E-16          b0 = 0                        
+b1 = 0                        keta = -7.79943E-2            lketa = 2.4402E-9             
+wketa = 3.371629E-9           a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.149369              lvoff = -1.226235E-9          wvoff = -7.837735E-10         
+pvoff = 1.980284E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.264979            lnfactor = 4.997541E-8        wnfactor = 3.563301E-9        
+pnfactor = 1.407068E-16       eta0 = 2.963491E-3            etab = -0.026723              
+letab = 5.371771E-9           dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.242172E-3         
+lpdiblc2 = -2.597034E-10      wpdiblc2 = 2.928076E-10       ppdiblc2 = -6.226163E-17      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
23:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_n+dlmis_n)           lmax = 1.0E-7-(dxl_n+dlmis_n)           wmin = 3.0E-7-(dxw_n+dwmis_n)           
+wmax = 5.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.33943+dvth0_n+vthmis_n        lvth0 = 8.777858E-10+dlvth0_n wvth0 = 7.314006E-10+dwvth0_n 
+pvth0 = 1.603287E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.23791E-2              lk2 = 5.107721E-11            wk2 = -1.760528E-9            
+pk2 = 1.417846E-16            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.46585E-2+du0_n         lu0 = 3.57012E-11+dlu0_n      wu0 = 4.465776E-10+dwu0_n     
+pu0 = -5.872809E-17+dpu0_n    ua = -1.993215E-9             lua = 1.122999E-17            
+wua = 6.545105E-17            pua = -4.364133E-24           ub = 2.268421E-18             
+lub = 2.907537E-28            wub = -2.222956E-26           pub = -1.913513E-33           
+uc = 5.28944E-11              luc = 1.728991E-18            wuc = 5.483459E-18            
+puc = -5.117814E-25           ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1E-3                     ags = 5.76775                 wags = -2.618904E-8           
+b0 = 0                        b1 = 0                        keta = -8.20943E-2            
+lketa = 2.842E-9              wketa = 3.371629E-9           a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.165553              lvoff = 3.598143E-10          wvoff = 3.30615E-9            
+pvoff = -2.02784E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.53958             lnfactor = 1.210645E-7        wnfactor = 1.519509E-9        
+pnfactor = 3.409984E-16       eta0 = 7.260553E-3            leta0 = -4.211121E-10         
+etab = 0.028091               dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 1.41108E-2          
+lpdiblc2 = -8.348284E-10      wpdiblc2 = -1.042551E-9       ppdiblc2 = 6.860349E-17       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
24:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_n+dlmis_n)           wmin = 3.0E-7-(dxw_n+dwmis_n)           
+wmax = 5.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.342412+dvth0_n+vthmis_n       lvth0 = 7.048128E-10+dlvth0_n wvth0 = -4.507398E-9+dwvth0_n 
+pvth0 = 4.64179E-16+dpvth0_n  phin = 0                      k1 = 0.30264                  
+k2 = -6.64756E-2              lk2 = 3.188669E-9             wk2 = 1.583244E-8             
+pk2 = -8.786077E-16           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.47947E-2+du0_n         lu0 = 2.780655E-11+dlu0_n     wu0 = 1.294477E-10+dwu0_n     
+pu0 = -4.033455E-17+dpu0_n    ua = -2.036757E-9             lua = 1.375539E-17            
+wua = 5.882359E-17            pua = -3.979741E-24           ub = 2.350322E-18             
+lub = -4.459499E-27           wub = -5.739559E-26           pub = 1.261163E-34            
+uc = -9.460524E-11            luc = 1.028397E-17            wuc = 6.842322E-17            
+puc = -4.162287E-24           ud = 0                        vsat = 1.186922E5+dvsat_n     
+lvsat = 1.068058E-3           wvsat = 4.044781E-3           pvsat = -2.345973E-10         
+a0 = 1E-3                     ags = 5.76775                 lags = 0                      
+wags = -2.618904E-8           pags = 0                      b0 = 0                        
+b1 = 0                        keta = 2.31457E-2             lketa = -3.26192E-9           
+wketa = -2.452341E-8          pketa = 1.617912E-15          a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.157693              lvoff = -9.608558E-11         wvoff = 1.350707E-11          
+pvoff = -1.181076E-17         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.231167            lnfactor = 1.389525E-7        wnfactor = 6.509821E-10       
+pnfactor = 3.91373E-16        eta0 = 0                      etab = 0.132798               
+letab = -6.073033E-9          wetab = -1.043707E-8          petab = 6.0535E-16            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = -1.75958E-2         lpdiblc1 = 1.020559E-9        
+wpdiblc1 = 4.231353E-9        ppdiblc1 = -2.454185E-16      pdiblc2 = 1.910801E-4         
+pdiblcb = 1                   drout = 0.871183              ldrout = -1.804864E-8         
+wdrout = -7.195386E-8         pdrout = 4.173324E-15         pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
25:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_n+dlmis_n)           lmax = 1.1E-5-(dxl_n+dlmis_n)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.349488+dvth0_n+vthmis_n       lvth0 = 0+dlvth0_n            wvth0 = 0+dwvth0_n            
+pvth0 = 0+dpvth0_n            phin = 0                      k1 = 0.30264                  
+k2 = -1.21781E-2              lk2 = 3.043477E-9             wk2 = 5.042589E-10            
+pk2 = -9.008692E-16           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.49507E-2+du0_n         lu0 = -2.610309E-10+dlu0_n    wu0 = -1.699856E-12+dwu0_n    
+pu0 = 2.634031E-17+dpu0_n     ua = -1.936611E-9             lua = -3.118543E-17           
+wua = 5.864088E-18            pua = 6.434086E-24            ub = 2.26587E-18              
+lub = 8.774737E-27            wub = 7.689905E-27            pub = -9.764493E-33           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.770469                 la0 = -1.057674E-6            wa0 = 1.592225E-8             
+pa0 = 1.597947E-14            ags = 1.016697                lags = 8.232935E-7            
+b0 = 0                        b1 = 0                        keta = -6.78466E-2            
+lketa = 6.141699E-8           wketa = 3.397866E-10          pketa = -3.397186E-15         
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.153733              lvoff = -6.034418E-10         wvoff = 1.072702E-10          
+pvoff = 1.786188E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.073035            lnfactor = -6.661836E-8       wnfactor = 3.845746E-9        
+pnfactor = 1.971904E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.622754E-3         
+lpdiblc2 = -8.039144E-10      wpdiblc2 = -4.962212E-12      ppdiblc2 = 4.96122E-17        
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
26:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_n+dlmis_n)           lmax = 2.0E-6-(dxl_n+dlmis_n)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.349059+dvth0_n+vthmis_n       lvth0 = 7.586077E-11+dlvth0_n wvth0 = -2.319752E-10+dwvth0_n 
+pvth0 = 5.541952E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.23769E-2              lk2 = 3.440782E-9             wk2 = 5.631189E-10            
+pk2 = -1.018472E-15           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.51036E-2+du0_n         lu0 = -5.665364E-10+dlu0_n    wu0 = -6.287662E-11+dwu0_n    
+pu0 = 1.485715E-16+dpu0_n     ua = -1.909483E-9             lua = -8.538719E-17           
+wua = -3.060751E-18           pua = 2.426591E-23            ub = 2.225764E-18             
+lub = 8.89083E-26             wub = 1.597437E-26            pub = -2.631686E-32           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.931772                 la0 = 6.180413E-7             wa0 = 1.423204E-8             
+pa0 = 1.935651E-14            ags = 0.162436                lags = 2.530107E-6            
+wags = 2.879445E-8            pags = -5.753132E-14          b0 = 0                        
+b1 = 0                        keta = -1.61281E-2            lketa = -4.191659E-8          
+wketa = -1.662212E-9          pketa = 6.028062E-16          a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.15528               lvoff = 2.487055E-9           wvoff = 3.914216E-10          
+pvoff = -3.891158E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.885301            lnfactor = 3.084726E-7        wnfactor = 1.998548E-8        
+pnfactor = -1.252816E-14      eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.969552E-3         
+lpdiblc2 = -1.496819E-9       wpdiblc2 = -2.018822E-10      ppdiblc2 = 4.430583E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
27:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                               
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_n+dlmis_n)           lmax = 1.0E-6-(dxl_n+dlmis_n)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.348784+dvth0_n+vthmis_n       lvth0 = 3.503989E-10+dlvth0_n wvth0 = 4.272566E-10+dwvth0_n 
+pvth0 = -1.037181E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -6.528617E-3             lk2 = -2.395833E-9            wk2 = -4.476281E-10           
+pk2 = -9.746085E-18           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.34204E-2+du0_n         lu0 = 1.113296E-9+dlu0_n      wu0 = 2.594938E-10+dwu0_n     
+pu0 = -1.731542E-16+dpu0_n    ua = -2.1266E-9               lua = 1.312952E-16            
+wua = 3.804818E-17            pua = -1.67608E-23            ub = 2.398431E-18             
+lub = -8.341353E-26           wub = -1.720057E-26           pub = 6.791732E-33            
+uc = 6.698292E-11             luc = -8.133177E-19           wuc = 5.0489E-19              
+puc = -5.038802E-25           ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.438993                 la0 = 1.118354E-7             wa0 = 4.662625E-8             
+pa0 = -1.297291E-14           ags = 0.876787                lags = 1.817185E-6            
+wags = -1.127899E-8           pags = -1.753802E-14          b0 = 0                        
+b1 = 0                        keta = -5.81287E-2            wketa = -1.058197E-9          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.151803              lvoff = -9.831402E-10         wvoff = -1.859966E-10         
+pvoff = 1.871476E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.015576            lnfactor = 1.784584E-7        wnfactor = 1.35382E-8         
+pnfactor = -6.093768E-15      eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 6.946556E-3         
+lpdiblc2 = 5.221321E-10       wpdiblc2 = 3.969249E-10       ppdiblc2 = -1.545511E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
28:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                 
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_n+dlmis_n)           lmax = 5.0E-7-(dxl_n+dlmis_n)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.349255+dvth0_n+vthmis_n       lvth0 = 1.157435E-10+dlvth0_n wvth0 = -1.587726E-10+dwvth0_n 
+pvth0 = 1.881244E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.34549E-2              lk2 = 1.053451E-9             wk2 = 1.589492E-10            
+pk2 = -3.118215E-16           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.56718E-2+du0_n         lu0 = -7.907061E-12+dlu0_n    wu0 = -3.119788E-11+dwu0_n    
+pu0 = -2.838973E-17+dpu0_n    ua = -1.872153E-9             lua = 4.580635E-18            
+wua = 4.201744E-18            pua = 9.472553E-26            ub = 2.225573E-18             
+lub = 2.669682E-27            wub = 4.447707E-27            pub = -3.989108E-33           
+uc = 5.932589E-11             luc = 2.99988E-18             wuc = 7.11763E-19             
+puc = -6.06903E-25            ud = 0                        vsat = 1.371068E5+dvsat_n     
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.070889                 la0 = -2.028492E-7            wa0 = 2.561741E-8             
+pa0 = -2.510506E-15           ags = 4.19311                 lags = 1.656562E-7            
+wags = -4.307845E-8           pags = -1.701894E-15          b0 = 0                        
+b1 = 0                        keta = -5.79318E-2            lketa = -9.804344E-11         
+wketa = -2.566872E-9          pketa = 7.513201E-16          a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.152827              lvoff = -4.731656E-10         wvoff = 2.397616E-10          
+pvoff = -2.488E-17            voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.272943            lnfactor = 5.028982E-8        wnfactor = 1.206049E-9        
+pnfactor = 4.764205E-17       eta0 = 2.647713E-3            leta0 = 1.572573E-10          
+weta0 = 9.347022E-11          peta0 = -4.654817E-17         etab = -0.026723              
+letab = 5.371771E-9           dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.799015E-3         
+lpdiblc2 = -4.003927E-10      wpdiblc2 = 1.27982E-10        ppdiblc2 = -2.061758E-17      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
29:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_n+dlmis_n)           lmax = 1.0E-7-(dxl_n+dlmis_n)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.344382+dvth0_n+vthmis_n       lvth0 = 5.933338E-10+dlvth0_n wvth0 = -7.34304E-10+dwvth0_n 
+pvth0 = 2.445265E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.16001E-2              lk2 = 8.71686E-10             wk2 = -1.991112E-9            
+pk2 = -1.011156E-16           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.91549E-2+du0_n         lu0 = -3.492531E-10+dlu0_n    wu0 = -8.843418E-10+dwu0_n    
+pu0 = 5.521838E-17+dpu0_n     ua = -1.519581E-9             lua = -2.997144E-17           
+wua = -7.474483E-17           pua = 7.831489E-24            ub = 2.091451E-18             
+lub = 1.581366E-26            wub = 3.015367E-26            pub = -6.508292E-33           
+uc = 9.555014E-11             luc = -5.500962E-19           wuc = -7.142639E-18           
+puc = 1.628285E-25            ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1E-3                     ags = 5.883479                wags = -6.044471E-8           
+b0 = 0                        b1 = 0                        keta = -9.75185E-2            
+lketa = 3.781446E-9           wketa = 7.937171E-9           pketa = -2.780761E-16         
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.154763              lvoff = -2.834169E-10         wvoff = 1.122883E-10          
+pvoff = -1.238761E-17         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.542976            lnfactor = 1.218266E-7        wnfactor = 5.144487E-10       
+pnfactor = 1.154189E-16       eta0 = 1.13187E-2             leta0 = -6.924954E-10         
+weta0 = -1.2012E-9            peta0 = 8.032947E-17          etab = 0.028091               
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 1.10921E-2          
+lpdiblc2 = -6.251199E-10      wpdiblc2 = -1.490316E-10      ppdiblc2 = 6.529758E-18       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
30:type=n  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    tempmod = 0                   permod = 1                    
+rgatemod = 0                  wpemod = 1                                                  
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_n+dlmis_n)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_n+dwmis_n)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_n+toxmis_n                  toxm = tox_n+toxmis_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dw and dl parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_n+dlmis_n)                  
+xw = 0+(dxw_n+dwmis_n)                  
//*** flicker noise model parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//***layout-dependent parasitics model parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = 0.31918+dvth0_n+vthmis_n        lvth0 = 2.055032E-9+dlvth0_n  wvth0 = 2.369356E-9+dwvth0_n  
+pvth0 = 6.451425E-17+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = 1.44261E-2               lk2 = -6.378356E-10           wk2 = -8.114445E-9            
+pk2 = 2.540377E-16            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** mobility related parameter ***
+u0 = 1.54945E-2+du0_n         lu0 = -1.369512E-10+dlu0_n    wu0 = -7.771E-11+dwu0_n       
+pu0 = 8.43373E-18+dpu0_n      ua = -2.002662E-9             lua = -1.952729E-18           
+wua = 4.873148E-17            pua = 6.698635E-25            ub = 2.386834E-18             
+lub = -1.318563E-27           wub = -6.820308E-26           pub = -8.036008E-34           
+uc = 2.056029E-10             luc = -6.933158E-18           wuc = -2.04384E-17            
+puc = 9.339827E-25            ud = 0                        vsat = 1.464295E5+dvsat_n     
+lvsat = -5.407079E-4          wvsat = -4.165475E-3          pvsat = 2.415975E-10          
+a0 = 1E-3                     ags = 5.439739                lags = 2.573695E-8            
+wags = 7.090303E-8            pags = -7.61817E-15           b0 = 0                        
+b1 = 0                        keta = -0.09481               lketa = 3.624356E-9           
+wketa = 1.039147E-8           pketa = -4.204252E-16         a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.156762              lvoff = -1.675187E-10         wvoff = -2.622126E-10         
+pvoff = 9.33344E-18           voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.232622            lnfactor = 1.398271E-7        wnfactor = 2.203608E-10       
+pnfactor = 1.32476E-16        eta0 = 9.63491E-4             etab = 0.142293               
+letab = -6.623709E-9          wetab = -1.324742E-8          petab = 7.683503E-16          
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 1.441266               pdiblc1 = -5.427875E-3        lpdiblc1 = 3.148168E-10       
+wpdiblc1 = 6.296336E-10       ppdiblc1 = -3.651875E-17      pdiblc2 = 0                   
+pdiblcb = 1                   drout = 0.67198               ldrout = -6.494845E-9         
+wdrout = -1.298969E-8         pdrout = 7.53402E-16          pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** gate dielectric tunneling current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** well proximity effect model parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
}
ends gpdk045_nmos1v



inline subckt gpdk045_pmos1v ( d g s b ) 
parameters
+l=1e-6 w=1e-6 multi=1 nf=1 factor=1
+dmcg=8.5E-8 	
+xw=0+dxw_p
+ad=2*dmcg/factor*(w/nf+xw/factor) 
+as=2*dmcg/factor*(w/nf+xw/factor)
+pd=4*dmcg/factor+2*(w/nf+xw/factor) 
+ps=4*dmcg/factor+2*(w/nf+xw/factor)
+nrd=dmcg/factor/(w/nf+xw/factor)
+nrs=dmcg/factor/(w/nf+xw/factor)
+sa=6.1E-7/factor 
+sb=6.1E-7/factor 
+sd=2*dmcg/factor
+sca=1E-6/factor
+scb=1E-6/factor 
+scc=1E-6/factor
+misa1=rp1  misa2=rp2
+fac1=0.621*misa1+0.276*misa2
+fac2=0.621*misa1-0.276*misa2
+lef=l*factor
+wef=w/nf*factor
+geo_fac =1/sqrt(multi*nf*lef*wef*1e12)
+vthmis_p= 0.00218*geo_fac*fac1 
+dlmis_p= 0.00131*geo_fac*lef*fac2 
+dwmis_p= -0.00131*geo_fac*wef*fac2 
+toxmis_p= 0.00131*geo_fac*tox_p*fac2 
gpdk045_pmos1v ( d n1 s b ) pch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
//********include rg model ***************//
include "gpdk045_mos.scs"   section = res_rg
xrg ( g n1 ) ressppoly_rg  ll=(w/3/nf/nf)*factor+5e-9 ww=l*factor  mf =multi
                 
model pch bsim4 {
1:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p+dlmis_p)           lmax = 1.1E-5-(dxl_p+dlmis_p)           wmin = 2.0E-6-(dxw_p+dwmis_p)           
+wmax = 1.1E-5-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+(dxl_p+dlmis_p)                
+xw = 0.0+(dxw_p+dwmis_p)                
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.288698+dvth0_p+vthmis_p      lvth0 = 9.263001E-9+dlvth0_p  wvth0 = 1.029638E-8+dwvth0_p  
+pvth0 = -6.341168E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -8.103705E-3             lk2 = -3.276035E-9            wk2 = 3.410333E-10            
+pk2 = -3.410333E-15           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 0.0230515+du0_p          lu0 = -2.679199E-9+dlu0_p     wu0 = -3.385616E-9+dwu0_p     
+pu0 = 3.783728E-15+dpu0_p     ua = 5.151217E-11             lua = -3.362198E-17           
+wua = -5.231372E-17           pua = 1.338104E-23            ub = 1.55638E-18              
+lub = -4.491856E-25           wub = -5.285709E-25           pub = 6.597406E-31            
+uc = 7.043061E-11             luc = -4.913762E-17           ud = 0                        
+vsat = 117731.5+dvsat_p       a0 = 2.353824                 la0 = 1.639705E-7             
+wa0 = 6.701246E-7             pa0 = -1.636132E-12           ags = 1.121996                
+lags = 9.247601E-7            wags = 1.432197E-7            pags = -3.175827E-13          
+b0 = 0                        b1 = 0                        keta = -0.105855              
+lketa = -8.503601E-9          wketa = -8.485076E-9          pketa = 8.485076E-14          
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.98938E-2            lvoff = 1.151389E-8           wvoff = 1.102253E-8           
+pvoff = -1.25565E-14          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.33243             lnfactor = 6.322266E-8        wnfactor = -3.033706E-8       
+pnfactor = 5.237016E-15       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.09524E-2          
+lpdiblc2 = 9.314481E-10       wpdiblc2 = 1.282359E-9        ppdiblc2 = -3.274831E-15      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
2:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p+dlmis_p)           lmax = 2.0E-6-(dxl_p+dlmis_p)           wmin = 2.0E-6-(dxw_p+dwmis_p)           
+wmax = 1.1E-5-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.286578+dvth0_p+vthmis_p      lvth0 = 5.023342E-9+dlvth0_p  wvth0 = 1.285999E-8+dwvth0_p  
+pvth0 = -1.146839E-14+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -9.741722E-3             wk2 = -1.364133E-9            k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.23473E-2+du0_p         lu0 = -1.270823E-9+dlu0_p     wu0 = -2.593464E-9+dwu0_p     
+pu0 = 2.199423E-15+dpu0_p     ua = 4.59749E-11              lua = -2.254745E-17           
+wua = -6.792504E-17           pua = 4.460368E-23            ub = 1.394442E-18             
+lub = -1.253081E-25           wub = -2.720312E-25           pub = 1.466611E-31            
+uc = 4.245963E-11             luc = 6.804335E-18            wuc = 3.394756E-17            
+puc = -6.789511E-23           ud = 0                        vsat = 1.177315E5+dvsat_p     
+a0 = 2.435809                 wa0 = -1.479417E-7            ags = 1.103433                
+lags = 9.618857E-7            wags = 4.527397E-8            pags = -1.216912E-13          
+b0 = 0                        b1 = 0                        keta = -0.135073              
+lketa = 4.993248E-8           wketa = 8.332888E-8           pketa = -9.877715E-14         
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.64666E-2            lvoff = 4.659386E-9           wvoff = 8.261531E-9           
+pvoff = -7.034502E-15         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.328351            lnfactor = 7.138037E-8        wnfactor = -2.471329E-8       
+pnfactor = -6.010539E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.12459E-2          
+lpdiblc2 = 3.443418E-10       wpdiblc2 = -3.51355E-10       ppdiblc2 = -7.402142E-18      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
3:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_p+dlmis_p)           lmax = 1.0E-6-(dxl_p+dlmis_p)           wmin = 2.0E-6-(dxw_p+dwmis_p)           
+wmax = 1.1E-5-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.281971+dvth0_p+vthmis_p      lvth0 = 4.161374E-10+dlvth0_p wvth0 = 5.344347E-9+dwvth0_p  
+pvth0 = -3.952744E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -9.741722E-3             wk2 = -1.364133E-9            k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.09644E-2+du0_p         lu0 = 1.121201E-10+dlu0_p     wu0 = -9.785632E-10+dwu0_p    
+pu0 = 5.845225E-16+dpu0_p     ua = 3.658013E-11             lua = -1.315267E-17           
+wua = -4.934016E-17           pua = 2.60188E-23             ub = 1.20891E-18              
+lub = 6.022366E-26            wub = -2.324297E-25           pub = 1.070596E-31            
+uc = 6.221217E-11             luc = -1.29482E-17            wuc = -4.050973E-17           
+puc = 6.562172E-24            ud = 0                        vsat = 1.177315E5+dvsat_p     
+a0 = 3.175174                 la0 = -7.393642E-7            wa0 = -2.093795E-7            
+pa0 = 6.143778E-14            ags = 1.263312                lags = 8.020065E-7            
+wags = -3.837517E-7           pags = 3.073345E-13           b0 = 0                        
+b1 = 0                        keta = -8.27813E-2            lketa = -2.358872E-9          
+wketa = -3.89856E-8           pketa = 2.353733E-14          a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.17999E-2            lvoff = -7.225053E-12         wvoff = 4.126448E-9           
+pvoff = -2.899419E-15         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.333318            lnfactor = 6.641339E-8        wnfactor = -4.149641E-8       
+pnfactor = 1.077258E-14       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.27197E-2          
+lpdiblc2 = -1.129468E-9       wpdiblc2 = -1.5658E-9         ppdiblc2 = 1.207043E-15       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
4:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_p+dlmis_p)           lmax = 5.0E-7-(dxl_p+dlmis_p)           wmin = 2.0E-6-(dxw_p+dwmis_p)           
+wmax = 1.1E-5-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.275585+dvth0_p+vthmis_p      lvth0 = -2.776426E-9+dlvth0_p wvth0 = -1.39222E-9+dwvth0_p  
+pvth0 = -5.844608E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -8.734273E-3             lk2 = -5.037244E-10           wk2 = -1.520113E-9            
+pk2 = 7.798989E-17            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.07851E-2+du0_p         lu0 = 2.017547E-10+dlu0_p     wu0 = 5.89704E-10+dwu0_p      
+pu0 = -1.996111E-16+dpu0_p    ua = 1.049063E-11             lua = -1.079212E-19           
+wua = 5.437182E-19            pua = 1.076861E-24            ub = 1.183295E-18             
+lub = 7.303113E-26            wub = 7.477397E-26            pub = -4.65422E-32            
+uc = 3.108169E-11             luc = 2.617039E-18            wuc = -1.703126E-17           
+puc = -5.177064E-24           ud = 0                        vsat = 1.177315E5+dvsat_p     
+a0 = 2.120307                 la0 = -2.119307E-7            wa0 = -1.081299E-7            
+pa0 = 1.081299E-14            ags = 2.472015                lags = 1.976549E-7            
+wags = 5.701919E-7            pags = -1.696374E-13          b0 = 0                        
+b1 = 0                        keta = -9.97782E-2            lketa = 6.139585E-9           
+wketa = 2.248882E-8           pketa = -7.199879E-15         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -3.79697E-2            lvoff = -1.922371E-9          wvoff = 1.102919E-10          
+pvoff = -8.913413E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.392253            lnfactor = 3.69457E-8         wnfactor = 1.796006E-8        
+pnfactor = -1.895565E-14      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.08806E-2          
+lpdiblc2 = -2.098993E-10      wpdiblc2 = 7.910077E-10       ppdiblc2 = 2.863889E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
5:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_p+dlmis_p)           lmax = 1.0E-7-(dxl_p+dlmis_p)           wmin = 2.0E-6-(dxw_p+dwmis_p)           
+wmax = 1.1E-5-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.310337+dvth0_p+vthmis_p      lvth0 = 6.98694E-10+dlvth0_p  wvth0 = -2.806521E-9+dwvth0_p 
+pvth0 = -4.430304E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -7.660604E-4             lk2 = -1.300546E-9            wk2 = -2.433084E-9            
+pk2 = 1.69287E-16             k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.39733E-2+du0_p         lu0 = -1.170701E-10+dlu0_p    wu0 = -8.823129E-9+dwu0_p     
+pu0 = 7.416722E-16+dpu0_p     ua = 9.411414E-12             wua = 1.131233E-17            
+pua = -1.223948E-30           ub = 1.448845E-18             lub = 4.647614E-26            
+wub = -1.46372E-24            pub = 1.073072E-31            uc = 2.898805E-11             
+luc = 2.826403E-18            wuc = -1.28896E-17            puc = -5.59123E-24            
+ud = 0                        vsat = 8.83204E4+dvsat_p      lvsat = 2.94111E-3            
+wvsat = 1.85036E-2            pvsat = -1.850502E-9          a0 = 1E-3                     
+ags = 4.448564                wags = -1.126182E-6           b0 = 0                        
+b1 = 0                        keta = 5.302681E-3            lketa = -4.368507E-9          
+wketa = 7.072747E-9           pketa = -5.658271E-15         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -7.82839E-2            lvoff = 2.109055E-9           wvoff = -1.09305E-8           
+pvoff = 2.127376E-16          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.213279            lnfactor = 5.484309E-8        wnfactor = -4.80473E-8        
+pnfactor = -1.235492E-14      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.05063E-2          
+lpdiblc2 = -1.724729E-10      wpdiblc2 = 4.725202E-9        ppdiblc2 = -3.647805E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
6:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_p+dlmis_p)           wmin = 2.0E-6-(dxw_p+dwmis_p)           
+wmax = 1.1E-5-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.361251+dvth0_p+vthmis_p      lvth0 = 3.75355E-9+dlvth0_p   wvth0 = -3.46667E-9+dwvth0_p  
+pvth0 = -4.034214E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -2.10585E-2              lk2 = -8.299958E-11           wk2 = 1.06507E-8              
+pk2 = -6.157398E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.87262E-2+du0_p         lu0 = -4.022427E-10+dlu0_p    wu0 = -2.002279E-9+dwu0_p     
+pu0 = 3.324212E-16+dpu0_p     ua = 9.411419E-12             lua = 0                       
+wua = 1.131231E-17            ub = 1.801744E-18             lub = 2.530217E-26            
+wub = -2.448186E-25           pub = 3.41731E-32             uc = -4.172837E-10            
+luc = 2.960271E-17            wuc = 8.699316E-16            puc = -5.85605E-23            
+ud = 0                        vsat = 1.191535E5+dvsat_p     lvsat = 1.091123E-3           
+wvsat = -2.112115E-6          pvsat = -7.401602E-10         a0 = 1E-3                     
+ags = 4.448564                wags = -1.126182E-6           b0 = 0                        
+b1 = 0                        keta = -0.137522              lketa = 4.200956E-9           
+wketa = 2.122737E-7           pketa = -1.797033E-14         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.107133              lvoff = 3.84E-9               wvoff = -7.38487E-9           
+voffl = -6.036214E-9          minv = 0                      nfactor = 0.450931            
+lnfactor = 4.058396E-8        wnfactor = -1.015821E-7       pnfactor = -9.14283E-15       
+eta0 = 3.11538E-2             etab = 0.175493               letab = -1.196063E-8          
+wetab = -1.048193E-7          petab = 6.289156E-15          dsub = 1.2725                 
+cit = 1E-4                    cdsc = 0                      cdscb = 0                     
+cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.04829E-2          
+lpdiblc2 = -1.710651E-10      wpdiblc2 = 9.61405E-10        ppdiblc2 = -1.389527E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
7:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p+dlmis_p)           lmax = 1.1E-5-(dxl_p+dlmis_p)           wmin = 1.0E-6-(dxw_p+dwmis_p)           
+wmax = 2.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.287228+dvth0_p+vthmis_p      lvth0 = 9.894545E-9+dlvth0_p  wvth0 = 7.388762E-9+dwvth0_p  
+pvth0 = -7.590498E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -7.93131E-3              lk2 = -4.99998E-9             k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.19348E-2+du0_p         lu0 = -1.401117E-9+dlu0_p     wu0 = -1.176503E-9+dwu0_p     
+pu0 = 1.255407E-15+dpu0_p     ua = 3.789645E-11             lua = -5.313043E-17           
+wua = -2.537891E-17           pua = 5.197295E-23            ub = 1.381669E-18             
+lub = -1.677064E-25           wub = -1.829542E-25           pub = 1.029144E-31            
+uc = 6.754658E-11             luc = -2.029733E-17           wuc = 5.705229E-18            
+puc = -5.705229E-23           ud = 0                        vsat = 1.177315E5+dvsat_p     
+a0 = 2.692968                 la0 = -6.670179E-7            wa0 = -7.74047E-10            
+pa0 = 7.74047E-15             ags = 1.189838                lags = 8.097828E-7            
+wags = 9.013293E-9            pags = -9.013293E-14          b0 = 0                        
+b1 = 0                        keta = -0.109517              lketa = 2.811767E-8           
+wketa = -1.240604E-9          pketa = 1.240604E-14          a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.67608E-2            lvoff = 6.899651E-9           wvoff = 4.82478E-9            
+pvoff = -3.428544E-15         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.333318            lnfactor = 6.415813E-8        wnfactor = -3.209392E-8       
+pnfactor = 3.386455E-15       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.15966E-2          
+lpdiblc2 = -6.843823E-10      wpdiblc2 = 7.837225E-12       ppdiblc2 = -7.837225E-17      
