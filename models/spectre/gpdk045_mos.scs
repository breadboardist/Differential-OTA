+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
8:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p+dlmis_p)           lmax = 2.0E-6-(dxl_p+dlmis_p)           wmin = 1.0E-6-(dxw_p+dwmis_p)           
+wmax = 2.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.283174+dvth0_p+vthmis_p      lvth0 = 1.786965E-9+dlvth0_p  wvth0 = 6.126582E-9+dwvth0_p  
+pvth0 = -5.066137E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.04313E-2              k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 0.021425+du0_p           lu0 = -3.816416E-10+dlu0_p    wu0 = -7.690157E-10+dwu0_p    
+pu0 = 4.404327E-16+dpu0_p     ua = 1.133123E-11             wua = 6.075688E-19            
+ub = 1.348428E-18             lub = -1.012252E-25           wub = -1.81007E-25            
+pub = 9.901996E-32            uc = 7.461729E-11             luc = -3.443875E-17           
+wuc = -2.966719E-17           puc = 1.369254E-23            ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 2.362624                 ags = 1.161347                
+lags = 8.667644E-7            wags = -6.929268E-8           pags = 6.647902E-14           
+b0 = 0                        b1 = 0                        keta = -0.095458              
+wketa = 4.962415E-9           a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.50565E-2            lvoff = 3.491025E-9           wvoff = 5.472125E-9           
+pvoff = -4.723235E-15         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.334016            lnfactor = 6.276227E-8        wnfactor = -3.591965E-8       
+pnfactor = 1.103791E-14       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 0.011114            
+lpdiblc2 = 2.809289E-10       wpdiblc2 = -9.036998E-11      ppdiblc2 = 1.180422E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
9:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_p+dlmis_p)           lmax = 1.0E-6-(dxl_p+dlmis_p)           wmin = 1.0E-6-(dxw_p+dwmis_p)           
+wmax = 2.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.279875+dvth0_p+vthmis_p      lvth0 = -1.512547E-9+dlvth0_p wvth0 = 1.197838E-9+dwvth0_p  
+pvth0 = -1.373933E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.04313E-2              k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.06527E-2+du0_p         lu0 = 3.906769E-10+dlu0_p     wu0 = -3.620605E-10+dwu0_p    
+pu0 = 3.347753E-17+dpu0_p     ua = 1.133123E-11             wua = 6.075688E-19            
+ub = 1.137011E-18             lub = 1.101924E-25            wub = -9.019776E-26           
+pub = 8.210703E-33            uc = 5.923069E-11             luc = -1.905214E-17           
+wuc = -3.461172E-17           puc = 1.863708E-23            ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 3.067296                 la0 = -7.078375E-7            
+wa0 = 4.025044E-9             pa0 = -9.288564E-16           ags = 1.085171                
+lags = 9.429403E-7            wags = -3.135084E-8           pags = 2.853718E-14           
+b0 = 0                        b1 = 0                        keta = -0.114329              
+lketa = 1.887098E-8           wketa = 2.342227E-8           pketa = -1.845986E-14         
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.02618E-2            lvoff = -1.303669E-9          wvoff = 1.083666E-9           
+pvoff = -3.347753E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.327794            lnfactor = 6.898403E-8        wnfactor = -3.056905E-8       
+pnfactor = 5.68731E-15        eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.17624E-2          
+lpdiblc2 = -3.674811E-10      wpdiblc2 = 3.280024E-10       ppdiblc2 = -3.003302E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
10:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_p+dlmis_p)           lmax = 5.0E-7-(dxl_p+dlmis_p)           wmin = 1.0E-6-(dxw_p+dwmis_p)           
+wmax = 2.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.276557+dvth0_p+vthmis_p      lvth0 = -3.171164E-9+dlvth0_p wvth0 = 5.302222E-10+dwvth0_p 
+pvth0 = 1.964144E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -9.413316E-3             lk2 = -5.089922E-10           wk2 = -1.768214E-10           
+pk2 = 8.841068E-17            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.11806E-2+du0_p         lu0 = 1.267238E-10+dlu0_p     wu0 = -1.927377E-10+dwu0_p    
+pu0 = -5.118386E-17+dpu0_p    ua = 9.604491E-12             lua = 8.633694E-19            
+wua = 2.296689E-18            pua = -8.445602E-25           ub = 1.255591E-18             
+lub = 5.090223E-26            wub = -6.824337E-26           pub = -2.766492E-33           
+uc = 2.11264E-11              wuc = 2.662431E-18            ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 2.064277                 la0 = -2.063277E-7            
+wa0 = 2.709164E-9             pa0 = -2.709164E-16           ags = 2.748222                
+lags = 1.114146E-7            wags = 2.379469E-8            pags = 9.644141E-16           
+b0 = 0                        b1 = 0                        keta = -0.074884              
+lketa = -8.514476E-10         wketa = -2.675721E-8          pketa = 6.629882E-15          
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -3.80642E-2            lvoff = -2.402455E-9          wvoff = 2.973792E-10          
+pvoff = 5.836798E-17          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.409871            lnfactor = 2.794566E-8        wnfactor = -1.689116E-8       
+pnfactor = -1.151637E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 0.011319            
+lpdiblc2 = -1.458055E-10      wpdiblc2 = -7.635344E-11      ppdiblc2 = -9.81523E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
11:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_p+dlmis_p)           lmax = 1.0E-7-(dxl_p+dlmis_p)           wmin = 1.0E-6-(dxw_p+dwmis_p)           
+wmax = 2.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.318192+dvth0_p+vthmis_p      lvth0 = 9.923601E-10+dlvth0_p wvth0 = 1.273562E-8+dwvth0_p  
+pvth0 = -1.024125E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -2.426757E-3             lk2 = -1.207648E-9            wk2 = 8.521289E-10            
+pk2 = -1.448435E-17           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 0.018311+du0_p           lu0 = 4.136891E-10+dlu0_p     wu0 = 2.378464E-9+dwu0_p      
+pu0 = -3.083041E-16+dpu0_p    ua = 1.823818E-11             wua = -6.148913E-18           
+ub = 4.894937E-19             lub = 1.275119E-25            wub = 4.340809E-25            
+pub = -5.299892E-32           uc = 2.11264E-11              wuc = 2.662431E-18            
+ud = 0                        vsat = 1.225451E5+dvsat_p     lvsat = -4.813637E-4          
+wvsat = -4.91989E-2           pvsat = 4.919801E-9           a0 = 1E-3                     
+ags = 3.862368                wags = 3.343883E-8            b0 = 0                        
+b1 = 0                        keta = 2.37312E-3             lketa = -8.577166E-9          
+wketa = 1.286805E-8           pketa = 2.667356E-15          a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -8.70239E-2            lvoff = 2.493508E-9           wvoff = 6.358989E-9           
+pvoff = -5.47793E-16          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.193012            lnfactor = 4.963147E-8        wnfactor = -7.955268E-9       
+pnfactor = -2.045226E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.32245E-2          
+lpdiblc2 = -3.363508E-10      wpdiblc2 = -6.519285E-10      ppdiblc2 = -4.05948E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
12:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_p+dlmis_p)           wmin = 1.0E-6-(dxw_p+dwmis_p)           
+wmax = 2.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.372351+dvth0_p+vthmis_p      lvth0 = 4.241926E-9+dlvth0_p  wvth0 = 1.849244E-8+dwvth0_p  
+pvth0 = -1.369535E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.51879E-2              lk2 = -4.419773E-10           wk2 = -9.625274E-10           
+pk2 = 9.439503E-17            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.77783E-2+du0_p         lu0 = -1.543481E-10+dlu0_p    wu0 = -1.271445E-10+dwu0_p    
+pu0 = -1.579675E-16+dpu0_p    ua = 1.823818E-11             lua = 0                       
+wua = -6.148913E-18           ub = 1.656104E-18             lub = 5.75153E-26             
+wub = 4.328858E-26            pub = -2.955138E-32           uc = 2.11264E-11              
+wuc = 2.662431E-18            ud = 0                        vsat = 1.289341E5+dvsat_p     
+lvsat = -8.647015E-4          wvsat = -1.93502E-2           pvsat = 3.12888E-9            
+a0 = 1E-3                     ags = 3.862368                wags = 3.343883E-8            
+b0 = 0                        b1 = 0                        keta = -0.216991              
+lketa = 4.584702E-9           wketa = 3.694816E-7           pketa = -1.872946E-14         
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.115477              lvoff = 4.200668E-9           wvoff = 9.120402E-9           
+pvoff = -7.134778E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.408082            lnfactor = 3.672732E-8        wnfactor = -1.681617E-8       
+pnfactor = -1.513571E-15      eta0 = 3.11538E-2             etab = 0.156383               
+letab = -1.081399E-8          wetab = -6.701428E-8          petab = 4.020857E-15          
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.30818E-2          
+lpdiblc2 = -3.277863E-10      wpdiblc2 = -4.179765E-9       ppdiblc2 = 1.710754E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
13:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p+dlmis_p)           lmax = 1.1E-5-(dxl_p+dlmis_p)           wmin = 5.0E-7-(dxw_p+dwmis_p)           
+wmax = 1.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.280565+dvth0_p+vthmis_p      lvth0 = 4.176975E-9+dlvth0_p  wvth0 = 8.71504E-10+dwvth0_p  
+pvth0 = -1.997489E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -7.847288E-3             lk2 = -5.840202E-9            wk2 = -8.219176E-11           
+pk2 = 8.219176E-16            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 0.020731+du0_p           lu0 = -1.285098E-10+dlu0_p    wu0 = 1.099321E-12+dwu0_p     
+pu0 = 1.052541E-17+dpu0_p     ua = 1.109496E-11             lua = 8.573662E-18            
+wua = 8.386878E-19            pua = -8.386878E-24           ub = 1.27088E-18              
+lub = -6.928108E-26           wub = -7.457885E-26           pub = 6.633347E-33            
+uc = 9.640722E-11             luc = -1.209172E-16           wuc = -2.252666E-17           
+puc = 4.13755E-23             ud = 0                        vsat = 1.177315E5+dvsat_p     
+a0 = 2.755215                 la0 = -1.289492E-6            wa0 = -6.166534E-8            
+pa0 = 6.166534E-13            ags = 1.230207                lags = 7.229842E-7            
+wags = -3.047644E-8           pags = -5.225281E-15          b0 = 0                        
+b1 = 0                        keta = -0.124888              lketa = 7.982228E-8           
+wketa = 1.379624E-8           pketa = -3.817215E-14         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.27781E-2            lvoff = 5.859945E-9           wvoff = 9.28809E-10           
+pvoff = -2.411488E-15         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.325062            lnfactor = 6.586256E-8        wnfactor = -2.401828E-8       
+pnfactor = 1.71915E-15        eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 0.011707            
+lpdiblc2 = -1.787639E-9       wpdiblc2 = -1.00085E-10       ppdiblc2 = 1.00085E-15        
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
14:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p+dlmis_p)           lmax = 2.0E-6-(dxl_p+dlmis_p)           wmin = 5.0E-7-(dxw_p+dwmis_p)           
+wmax = 1.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.276146+dvth0_p+vthmis_p      lvth0 = -4.662137E-9+dlvth0_p wvth0 = -7.484736E-10+dwvth0_p 
+pvth0 = 1.242466E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.07674E-2              wk2 = 3.28767E-10             k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.06421E-2+du0_p         lu0 = 4.928014E-11+dlu0_p     wu0 = -3.087454E-12+dwu0_p    
+pu0 = 1.889896E-17+dpu0_p     ua = 1.538179E-11             wua = -3.354751E-18           
+ub = 1.278187E-18             lub = -8.3896E-26             wub = -1.122963E-25           
+pub = 8.206826E-32            uc = 4.673321E-11             luc = -2.156918E-17           
+wuc = -2.390578E-18           puc = 1.103344E-24            ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 1.634615                 la0 = 9.517076E-7             
+wa0 = 7.121483E-7             pa0 = -9.309739E-13           ags = 1.114189                
+lags = 9.550194E-7            wags = -2.316245E-8           pags = -1.985326E-14          
+b0 = 0                        b1 = 0                        keta = -8.49774E-2            
+wketa = -5.289837E-9          a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -3.89808E-2            lvoff = -1.734509E-9          wvoff = -4.711641E-10         
+pvoff = 3.884578E-16          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.319765            lnfactor = 7.64562E-8         wnfactor = -2.197986E-8       
+pnfactor = -2.357692E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 9.704885E-3         
+lpdiblc2 = 2.216519E-9        wpdiblc2 = 1.28803E-9         ppdiblc2 = -1.775379E-15      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
15:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_p+dlmis_p)           lmax = 1.0E-6-(dxl_p+dlmis_p)           wmin = 5.0E-7-(dxw_p+dwmis_p)           
+wmax = 1.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.28002+dvth0_p+vthmis_p       lvth0 = -7.883886E-10+dlvth0_p wvth0 = 1.339768E-9+dwvth0_p  
+pvth0 = -8.457752E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.07674E-2              wk2 = 3.28767E-10             k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.02118E-2+du0_p         lu0 = 4.795121E-10+dlu0_p     wu0 = 6.923381E-11+dwu0_p     
+pu0 = -5.34223E-17+dpu0_p     ua = 1.538179E-11             wua = -3.354751E-18           
+ub = 1.051241E-18             lub = 1.430505E-25            wub = -6.296534E-27           
+pub = -2.393151E-32           uc = 2.516403E-11             wuc = -1.287234E-18           
+ud = 0                        vsat = 1.177315E5+dvsat_p     a0 = 3.36222                  
+la0 = -7.758967E-7            wa0 = -2.844733E-7            pa0 = 6.564769E-14            
+ags = 1.075988                lags = 9.932204E-7            wags = -2.236813E-8           
+pags = -2.064758E-14          b0 = 0                        b1 = 0                        
+keta = -8.49774E-2            wketa = -5.289837E-9          a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.039418              lvoff = -1.297377E-9          wvoff = 2.582234E-10          
+pvoff = -3.409297E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.322906            lnfactor = 7.331554E-8        wnfactor = -2.578772E-8       
+pnfactor = 1.450168E-15       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.27919E-2          
+lpdiblc2 = -8.704722E-10      wpdiblc2 = -6.790527E-10      ppdiblc2 = 1.917028E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
16:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_p+dlmis_p)           lmax = 5.0E-7-(dxl_p+dlmis_p)           wmin = 5.0E-7-(dxw_p+dwmis_p)           
+wmax = 1.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.275439+dvth0_p+vthmis_p      lvth0 = -3.07881E-9+dlvth0_p  wvth0 = -5.639281E-10+dwvth0_p 
+pvth0 = 1.060727E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -9.927653E-3             lk2 = -4.198678E-10           wk2 = 3.263111E-10            
+pk2 = 1.227965E-18            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.09695E-2+du0_p         lu0 = 1.006898E-10+dlu0_p     wu0 = 1.382337E-11+dwu0_p     
+pu0 = -2.571709E-17+dpu0_p    ua = 1.538179E-11             wua = -3.354751E-18           
+ub = 1.237041E-18             lub = 5.015041E-26            wub = -5.009744E-26           
+pub = -2.031053E-33           uc = 2.516403E-11             wuc = -1.287234E-18           
+ud = 0                        vsat = 1.177315E5+dvsat_p     a0 = 2.262783                 
+la0 = -2.261783E-7            wa0 = -1.914724E-7            pa0 = 1.914724E-14            
+ags = 2.622622                lags = 2.199035E-7            wags = 1.466587E-7            
+pags = -1.05161E-13           b0 = 0                        b1 = 0                        
+keta = -0.097409              lketa = 6.215849E-9           wketa = -4.722939E-9          
+pketa = -2.834493E-16         a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.037344              lvoff = -2.334359E-9          wvoff = -4.071463E-10         
+pvoff = -8.244905E-18         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.413193            lnfactor = 2.817217E-8        wnfactor = -2.014096E-8       
+pnfactor = -1.373215E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.14519E-2          
+lpdiblc2 = -2.004746E-10      wpdiblc2 = -2.062987E-10      ppdiblc2 = -4.467417E-17      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
17:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_p+dlmis_p)           lmax = 1.0E-7-(dxl_p+dlmis_p)           wmin = 5.0E-7-(dxw_p+dwmis_p)           
+wmax = 1.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.303883+dvth0_p+vthmis_p      lvth0 = -2.315703E-10+dlvth0_p wvth0 = -1.194003E-9+dwvth0_p 
+pvth0 = 1.690802E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.667648E-3             lk2 = -1.245868E-9            wk2 = 1.095578E-10            
+pk2 = 2.290329E-17            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.93044E-2+du0_p         lu0 = 2.672019E-10+dlu0_p     wu0 = 1.406683E-9+dwu0_p      
+pu0 = -1.650031E-16+dpu0_p    ua = 1.538179E-11             wua = -3.354752E-18           
+pua = 8.175722E-32            ub = 8.296347E-19             lub = 9.089101E-26            
+wub = 1.013503E-25            pub = -1.717583E-32           uc = 2.516403E-11             
+wuc = -1.287234E-18           ud = 0                        vsat = 7.943018E4+dvsat_p     
+lvsat = 3.830132E-3           wvsat = -7.017973E-3          pvsat = 7.019194E-10          
+a0 = 1E-3                     ags = 4.821657                wags = -9.049514E-7           
+b0 = 0                        b1 = 0                        keta = 5.588306E-3            
+lketa = -4.083886E-9          wketa = 9.722906E-9           pketa = -1.728034E-15         
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -8.24351E-2            lvoff = 2.17475E-9            wvoff = 1.870202E-9           
+pvoff = -2.359797E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.194575            lnfactor = 5.003397E-8        wnfactor = -9.483628E-9       
+pnfactor = -2.438948E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 0.012442            
+lpdiblc2 = -2.994882E-10      wpdiblc2 = 1.135027E-10       ppdiblc2 = -7.665432E-17      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
18:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_p+dlmis_p)           wmin = 5.0E-7-(dxw_p+dwmis_p)           
+wmax = 1.0E-6-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.353018+dvth0_p+vthmis_p      lvth0 = 2.7165E-9+dlvth0_p    wvth0 = -4.203147E-10+dwvth0_p 
+pvth0 = 1.226589E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.97479E-2              lk2 = -1.610538E-10           wk2 = 3.498085E-9             
+pk2 = -1.804083E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.82327E-2+du0_p         lu0 = -2.684997E-10+dlu0_p    wu0 = -5.716553E-10+dwu0_p    
+pu0 = -4.630277E-17+dpu0_p    ua = 1.538179E-11             wua = -3.35475E-18            
+ub = 1.697597E-18             lub = 3.881325E-26            wub = 2.699781E-27            
+pub = -1.125677E-32           uc = 2.516403E-11             wuc = -1.287234E-18           
+ud = 0                        vsat = 1.034144E5+dvsat_p     lvsat = 2.391226E-3           
+wvsat = 5.61351E-3            pvsat = -5.611507E-11         a0 = 1E-3                     
+ags = 4.821657                wags = -9.049514E-7           b0 = 0                        
+b1 = 0                        keta = 0.241349               lketa = -1.822952E-8          
+wketa = -7.887321E-8          pketa = 3.587733E-15          a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.103675              lvoff = 3.449149E-9           wvoff = -2.423932E-9          
+pvoff = 2.166831E-17          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.411391            lnfactor = 3.702499E-8        wnfactor = -2.005348E-8       
+pnfactor = -1.804757E-15      eta0 = 3.11538E-2             etab = 7.71088E-2             
+letab = -6.057559E-9          wetab = 1.053252E-8           petab = -6.319512E-16         
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 6.678874E-3         
+lpdiblc2 = 4.63003E-11        wpdiblc2 = 2.083621E-9        ppdiblc2 = -1.948614E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
19:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p+dlmis_p)           lmax = 1.1E-5-(dxl_p+dlmis_p)           wmin = 3.0E-7-(dxw_p+dwmis_p)           
+wmax = 5.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.279025+dvth0_p+vthmis_p      lvth0 = 2.823875E-9+dlvth0_p  wvth0 = 1.350417E-10+dwvth0_p 
+pvth0 = -1.350417E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -7.93129E-3              lk2 = -5.000185E-9            wk2 = -4.202092E-11           
+pk2 = 4.202092E-16            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.05849E-2+du0_p         lu0 = -6.062424E-10+dlu0_p    wu0 = 7.096342E-11+dwu0_p     
+pu0 = 2.389839E-16+dpu0_p     ua = 1.409575E-11             lua = -2.143415E-17           
+wua = -5.963288E-19           pua = 5.963288E-24            ub = 1.232665E-18             
+lub = -8.739768E-26           wub = -5.630408E-26           pub = 1.529697E-32            
+uc = 4.930144E-11             luc = -3.439635E-17           ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 2.493231                 la0 = 1.330351E-6             
+wa0 = 6.361928E-8             pa0 = -6.361928E-13           ags = 1.163903                
+lags = 7.377958E-7            wags = 1.230842E-9            pags = -1.230842E-14          
+b0 = 0                        b1 = 0                        keta = -8.94086E-2            
+lketa = -6.630367E-8          wketa = -3.170736E-9          pketa = 3.170736E-14          
+a1 = 0                        a2 = 1                        rdsw = 327.6                  
+prwb = -0.249981              prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.11187E-2            lvoff = 3.645993E-9           wvoff = 1.352745E-10          
+pvoff = -1.352745E-15         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.315827            lnfactor = 5.977564E-8        wnfactor = -1.960167E-8       
+pnfactor = 4.630002E-15       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.12289E-2          
+lpdiblc2 = 2.993495E-9        wpdiblc2 = 1.285557E-10       ppdiblc2 = -1.285557E-15      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
20:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p+dlmis_p)           lmax = 2.0E-6-(dxl_p+dlmis_p)           wmin = 3.0E-7-(dxw_p+dwmis_p)           
+wmax = 5.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.277675+dvth0_p+vthmis_p      lvth0 = 1.227641E-10+dlvth0_p wvth0 = -1.729598E-11+dwvth0_p 
+pvth0 = -1.045742E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.04314E-2              wk2 = 1.680837E-10            k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.02494E-2+du0_p         lu0 = 6.459536E-11+dlu0_p     wu0 = 1.846679E-10+dwu0_p     
+pu0 = 1.1575E-17+dpu0_p       ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.084096E-18             lub = 2.0974E-25              wub = -1.947927E-26           
+pub = -5.835266E-32           uc = 4.173424E-11             luc = -1.926196E-17           
+ud = 0                        vsat = 1.177315E5+dvsat_p     a0 = 4.348041                 
+la0 = -2.379269E-6            wa0 = -5.854504E-7            pa0 = 6.619466E-13            
+ags = 1.07296                 lags = 9.196831E-7            wags = -3.445892E-9           
+pags = -2.954952E-15          b0 = 0                        b1 = 0                        
+keta = -0.12256               wketa = 1.268295E-8           a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -3.89515E-2            lvoff = -6.885E-10            wvoff = -4.852189E-10         
+pvoff = -1.117587E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.312675            lnfactor = 6.607856E-8        wnfactor = -1.858919E-8       
+pnfactor = 2.605041E-15       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.46621E-2          
+lpdiblc2 = -3.873063E-9       wpdiblc2 = -1.082596E-9       ppdiblc2 = 1.136745E-15       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
21:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_p+dlmis_p)           lmax = 1.0E-6-(dxl_p+dlmis_p)           wmin = 3.0E-7-(dxw_p+dwmis_p)           
+wmax = 5.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.271438+dvth0_p+vthmis_p      lvth0 = -6.113969E-9+dlvth0_p wvth0 = -2.764031E-9+dwvth0_p 
+pvth0 = 1.700993E-15+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.04314E-2              wk2 = 1.680837E-10            k3 = -1.700953                
+k3b = 1.200306                w0 = 1.585076E-7              lpe0 = 7.519925E-8            
+lpeb = 5.608072E-8            dvtp0 = 2.2E-6                dvtp1 = 0.2                   
+dvt0 = 0.20341                dvt1 = 0.95146                dvt2 = 0.01                   
+dvt0w = 0                     dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.97725E-2+du0_p         lu0 = 5.415448E-10+dlu0_p     wu0 = 2.793301E-10+dwu0_p     
+pu0 = -8.308724E-17+dpu0_p    ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.259104E-18             lub = 3.473224E-26            wub = -1.056997E-25           
+pub = 2.786782E-32            uc = 2.247228E-11             ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 2.559403                 la0 = -5.906308E-7            
+wa0 = 9.944525E-8             pa0 = -2.294911E-14           ags = 1.036174                
+lags = 9.564694E-7            wags = -3.328146E-9           pags = -3.072698E-15          
+b0 = 0                        b1 = 0                        keta = -0.12256               
+wketa = 1.268295E-8           a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.036359              lvoff = -3.280905E-9          wvoff = -1.204599E-9          
+pvoff = 6.076212E-16          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.287815            lnfactor = 9.093895E-8        wnfactor = -9.006551E-9       
+pnfactor = -6.977599E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.05922E-2          
+lpdiblc2 = 1.968623E-10       wpdiblc2 = 3.728615E-10       ppdiblc2 = -3.187118E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
22:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_p+dlmis_p)           lmax = 5.0E-7-(dxl_p+dlmis_p)           wmin = 3.0E-7-(dxw_p+dwmis_p)           
+wmax = 5.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.277431+dvth0_p+vthmis_p      lvth0 = -3.117652E-9+dlvth0_p wvth0 = 3.886607E-10+dwvth0_p 
+pvth0 = 1.246475E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -9.131319E-3             lk2 = -6.500314E-10           wk2 = -5.450729E-11           
+pk2 = 1.112955E-16            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.07214E-2+du0_p         lu0 = 6.708303E-11+dlu0_p     wu0 = 1.324473E-10+dwu0_p     
+pu0 = -9.645837E-18+dpu0_p    ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.228926E-18             lub = 4.98212E-26             wub = -4.621686E-26           
+pub = -1.873621E-33           uc = 2.247228E-11             ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 1.722426                 la0 = -1.721426E-7            
+wa0 = 6.693379E-8             pa0 = -6.693379E-15           ags = 2.949112                
+wags = -9.473542E-9           b0 = 0                        b1 = 0                        
+keta = -0.149451              lketa = 1.344529E-8           wketa = 2.016429E-8           
+pketa = -3.740672E-15         a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -3.84328E-2            lvoff = -2.244035E-9          wvoff = 1.135215E-10          
+pvoff = -5.143892E-17         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.41333             lnfactor = 2.818153E-8        wnfactor = -2.020637E-8       
+pnfactor = -1.377692E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.12807E-2          
+lpdiblc2 = -1.473864E-10      wpdiblc2 = -1.244386E-10      ppdiblc2 = -7.00617E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
23:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_p+dlmis_p)           lmax = 1.0E-7-(dxl_p+dlmis_p)           wmin = 3.0E-7-(dxw_p+dwmis_p)           
+wmax = 5.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.301242+dvth0_p+vthmis_p      lvth0 = -7.364622E-10+dlvth0_p wvth0 = -2.489982E-9+dwvth0_p 
+pvth0 = 4.125117E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -3.986993E-3             lk2 = -1.164464E-9            wk2 = 1.218702E-9             
+pk2 = -1.602539E-17           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.16202E-2+du0_p         lu0 = -2.279875E-11+dlu0_p    wu0 = 2.991554E-10+dwu0_p     
+pu0 = -2.631665E-17+dpu0_p    ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.215498E-18             lub = 5.116405E-26            wub = -8.317472E-26           
+pub = 1.822165E-33            uc = 2.247228E-11             ud = 0                        
+vsat = 6.475225E4+dvsat_p     lvsat = 5.297925E-3           a0 = 1E-3                     
+ags = 2.949112                wags = -9.473542E-9           b0 = 0                        
+b1 = 0                        keta = 4.38547E-2             lketa = -5.885286E-9          
+wketa = -8.576646E-9          pketa = -8.665787E-16         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -8.28665E-2            lvoff = 2.199332E-9           wvoff = 2.076483E-9           
+pvoff = -2.47735E-16          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.194643            lnfactor = 5.005021E-8        wnfactor = -9.516117E-9       
+pnfactor = -2.446716E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.33727E-2          
+lpdiblc2 = -3.565839E-10      wpdiblc2 = -3.315524E-10      ppdiblc2 = -4.935033E-17      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
24:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_p+dlmis_p)           wmin = 3.0E-7-(dxw_p+dwmis_p)           
+wmax = 5.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.363005+dvth0_p+vthmis_p      lvth0 = 2.969312E-9+dlvth0_p  wvth0 = 4.355781E-9+dwvth0_p  
+pvth0 = 1.760766E-18+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.59612E-2              lk2 = -4.460132E-10           wk2 = 1.687223E-9             
+pk2 = -4.413669E-17           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.77547E-2+du0_p         lu0 = -3.908753E-10+dlu0_p    wu0 = -3.430577E-10+dwu0_p    
+pu0 = 1.2219E-17+dpu0_p       ua = 3.378668E-12             wua = 2.385315E-18            
+ub = 1.790032E-18             lub = 1.669197E-26            wub = -4.150437E-26           
+pub = -6.780558E-34           uc = 2.247228E-11             ud = 0                        
+vsat = 1.234994E5+dvsat_p     lvsat = 1.773095E-3           wvsat = -3.991381E-3          
+pvsat = 2.394828E-10          a0 = 1E-3                     ags = 2.949112                
+wags = -9.473542E-9           b0 = 0                        b1 = 0                        
+keta = 0.145602               lketa = -1.199014E-8          wketa = -3.308589E-8          
+pketa = 6.039757E-16          a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.104307              lvoff = 3.485746E-9           wvoff = -2.121885E-9          
+pvoff = 4.167002E-18          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.411527            lnfactor = 3.703715E-8        wnfactor = -2.011855E-8       
+pnfactor = -1.81057E-15       eta0 = 3.11538E-2             etab = 2.57253E-2             
+letab = -2.974547E-9          wetab = 3.510486E-8           petab = -2.106292E-15         
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.63451E-2          
+lpdiblc2 = -5.349321E-10      wpdiblc2 = -2.538927E-9       ppdiblc2 = 8.309217E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
25:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 2.0E-6-(dxl_p+dlmis_p)           lmax = 1.1E-5-(dxl_p+dlmis_p)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.278429+dvth0_p+vthmis_p      lvth0 = -3.137639E-9+dlvth0_p wvth0 = -3.081609E-11+dwvth0_p 
+pvth0 = 3.081609E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -7.891912E-3             lk2 = -5.393964E-9            wk2 = -5.297642E-11           
+pk2 = 5.297642E-16            k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.92035E-2+du0_p         lu0 = 3.906592E-10+dlu0_p     wu0 = 4.552849E-10+dwu0_p     
+pu0 = -3.83683E-17+dpu0_p     ua = 1.195233E-11             ub = 1.200175E-18             
+lub = -5.010175E-26           wub = -4.726483E-26           pub = 4.920706E-33            
+uc = 5.737161E-11             luc = -4.00267E-17            wuc = -2.245237E-18           
+puc = 1.566444E-24            ud = 0                        vsat = 1.177315E5+dvsat_p     
+a0 = 2.712976                 la0 = -8.671005E-7            wa0 = 2.483048E-9             
+pa0 = -2.483048E-14           ags = 1.174967                lags = 6.271594E-7            
+wags = -1.847219E-9           pags = 1.847219E-14           b0 = 0                        
+b1 = 0                        keta = -0.11312               lketa = 6.167879E-8           
+wketa = 3.425986E-9           pketa = -3.899184E-15         a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.09858E-2            lvoff = -1.46997E-9           wvoff = 9.829269E-11          
+pvoff = 7.058857E-17          voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.298047            lnfactor = 8.664679E-8        wnfactor = -1.465514E-8       
+pnfactor = -2.845934E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.15757E-2          
+lpdiblc2 = -4.747329E-10      wpdiblc2 = 3.206467E-11       ppdiblc2 = -3.206467E-16      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
26:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-6-(dxl_p+dlmis_p)           lmax = 2.0E-6-(dxl_p+dlmis_p)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.27786+dvth0_p+vthmis_p       lvth0 = -4.275484E-9+dlvth0_p wvth0 = 3.430756E-11+dwvth0_p 
+pvth0 = 1.779136E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.16802E-2              lk2 = 2.18253E-9              wk2 = 5.155112E-10            
+pk2 = -6.072111E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.93673E-2+du0_p         lu0 = 6.298573E-11+dlu0_p     wu0 = 4.300893E-10+dwu0_p     
+pu0 = 1.202283E-17+dpu0_p     ua = 1.195233E-11             ub = 1.175124E-18             
+wub = -4.480448E-26           uc = 4.635864E-11             luc = -1.800077E-17           
+wuc = -1.286575E-18           puc = -3.508814E-25           ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 2.279426                 wa0 = -9.932191E-9            
+ags = 1.041984                lags = 8.931262E-7            wags = 5.172093E-9            
+pags = 4.433569E-15           b0 = 0                        b1 = 0                        
+keta = -8.22802E-2            wketa = 1.476394E-9           a1 = 0                        
+a2 = 1                        rdsw = 327.6                  prwb = -0.249981              
+prwg = 0.25                   wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.13972E-2            lvoff = -6.471446E-10         wvoff = 1.952191E-10          
+pvoff = -1.232643E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.302568            lnfactor = 7.76038E-8         wnfactor = -1.577738E-8       
+pnfactor = -6.01445E-16       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.14534E-2          
+lpdiblc2 = -2.302554E-10      wpdiblc2 = -1.898908E-10      ppdiblc2 = 1.232643E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
27:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 5.0E-7-(dxl_p+dlmis_p)           lmax = 1.0E-6-(dxl_p+dlmis_p)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.281659+dvth0_p+vthmis_p      lvth0 = -4.763392E-10+dlvth0_p wvth0 = 7.969677E-11+dwvth0_p 
+pvth0 = 1.325243E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -1.11124E-2              lk2 = 1.614806E-9             wk2 = 3.575622E-10            
+pk2 = -4.492621E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.93511E-2+du0_p         lu0 = 7.920957E-11+dlu0_p     wu0 = 3.965711E-10+dwu0_p     
+pu0 = 4.554101E-17+dpu0_p     ua = 1.195233E-11             ub = 1.06643E-18              
+lub = 1.086942E-25            wub = -5.209502E-26           pub = 7.290539E-33            
+uc = 2.835787E-11             wuc = -1.637456E-18           ud = 0                        
+vsat = 1.177315E5+dvsat_p     a0 = 2.795285                 la0 = -5.158595E-7            
+wa0 = 3.381936E-8             pa0 = -4.375155E-14           ags = 1.265817                
+lags = 6.692929E-7            wags = -6.721823E-8           pags = 7.682389E-14           
+b0 = 0                        b1 = 0                        keta = -8.22802E-2            
+wketa = 1.476394E-9           a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -4.11305E-2            lvoff = -9.13785E-10          wvoff = 1.229E-10             
+pvoff = -5.094521E-17         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.312731            lnfactor = 6.74408E-8         wnfactor = -1.593875E-8       
+pnfactor = -4.40078E-16       eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.09634E-2          
+lpdiblc2 = 2.597392E-10       wpdiblc2 = 2.695785E-10       ppdiblc2 = -3.36205E-16       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
28:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 1.0E-7-(dxl_p+dlmis_p)           lmax = 5.0E-7-(dxl_p+dlmis_p)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.276412+dvth0_p+vthmis_p      lvth0 = -3.100063E-9+dlvth0_p wvth0 = 1.052377E-10+dwvth0_p 
+pvth0 = 1.197539E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -7.809711E-3             lk2 = -3.655552E-11           wk2 = -4.221974E-10           
+pk2 = -5.938225E-17           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 1.96163E-2+du0_p         lu0 = -5.338175E-11+dlu0_p    wu0 = 4.399148E-10+dwu0_p     
+pu0 = 2.386918E-17+dpu0_p     ua = 1.195233E-11             ub = 1.209676E-18             
+lub = 3.707127E-26            wub = -4.086112E-26           pub = 1.673592E-33            
+uc = 2.835787E-11             wuc = -1.637456E-18           ud = 0                        
+vsat = 1.225494E5+dvsat_p     lvsat = -2.408943E-3          wvsat = -1.340405E-3          
+pvsat = 6.702024E-10          a0 = 2.204208                 la0 = -2.203208E-7            
+wa0 = -6.710468E-8            pa0 = 6.710468E-15            ags = 2.604403                
+wags = 8.642956E-8            b0 = 0                        b1 = 0                        
+keta = -9.49368E-2            lketa = 6.328286E-9           wketa = 4.997633E-9           
+pketa = -1.760619E-15         a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -3.85647E-2            lvoff = -2.196689E-9          wvoff = 1.502322E-10          
+pvoff = -6.461131E-17         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.393899            lnfactor = 2.68568E-8         wnfactor = -1.480064E-8       
+pnfactor = -1.009132E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.18902E-2          
+lpdiblc2 = -2.036576E-10      wpdiblc2 = -2.94019E-10       ppdiblc2 = -5.440625E-17      
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
29:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 6.0E-8-(dxl_p+dlmis_p)           lmax = 1.0E-7-(dxl_p+dlmis_p)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.324011+dvth0_p+vthmis_p      lvth0 = 1.659806E-9+dlvth0_p  wvth0 = 3.84442E-9+dwvth0_p   
+pvth0 = -2.541644E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -5.319755E-3             lk2 = -2.855511E-10           wk2 = 1.589495E-9             
+pk2 = -2.605515E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.12229E-2+du0_p         lu0 = -2.14041E-10+dlu0_p     wu0 = 4.097097E-10+dwu0_p     
+pu0 = 2.688969E-17+dpu0_p     ua = 1.195233E-11             ub = 1.016076E-18             
+lub = 5.64312E-26             wub = -2.769288E-26           pub = 3.567683E-34            
+uc = 2.835787E-11             wuc = -1.637456E-18           ud = 0                        
+vsat = 1.657338E4+dvsat_p     lvsat = 8.188657E-3           wvsat = 0.013404              
+pvsat = -8.042429E-10         a0 = 1E-3                     ags = 2.604403                
+wags = 8.642956E-8            b0 = 0                        b1 = 0                        
+keta = 0.152975               lketa = -1.84629E-8           wketa = -3.893548E-8          
+pketa = 2.632692E-15          a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.086049              lvoff = 2.551746E-9           wvoff = 2.961934E-9           
+pvoff = -3.457815E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.18549             lnfactor = 4.769772E-8        wnfactor = -6.969748E-9       
+pnfactor = -1.792221E-15      eta0 = 3.11538E-2             etab = -2.38505E-2            
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.74584E-2          
+lpdiblc2 = -7.60473E-10       wpdiblc2 = -1.468255E-9       ppdiblc2 = 6.301736E-17       
+pdiblcb = 0                   drout = 1.132692              pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
30:type=p  minr=1e-60
//*** flag parameter ***
+version = 4.3                 binunit = 2                   mobmod = 0                    
+capmod = 2                    rdsmod = 0                    igcmod = 1                    
+igbmod = 1                    rbodymod = 0                  trnqsmod = 0                  
+acnqsmod = 0                  fnoimod = 1                   tnoimod = 0                   
+diomod = 1                    permod = 1                    rgatemod = 0                  
+wpemod = 0                      
//*** geometry range parameter ***
+lmin = 4E-8                   lmax = 6.0E-8-(dxl_p+dlmis_p)           wmin = 1.2E-7                 
+wmax = 3.0E-7-(dxw_p+dwmis_p)           
//*** process parameter ***
+epsrox = 3.9                  toxe = tox_p+toxmis_p                  toxm = tox_p+toxmis_p                  
+dtox = 3.29E-10               xj = 1.7E-7                   ndep = 8.5E17                 
+ngate = 8E19                  nsd = 1E20                    rsh = 9.68                    
+rshg = 0.1                    
//*** dw and dl parameter ***
+wint = 1.089287E-8            wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 2E-24                  ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+(dxl_p+dlmis_p)                  
+xw = 0+(dxw_p+dwmis_p)                  
//*** flicker noise model parameter ***
+noia = 1.45E42                noib = 3.57E26                noic = 2E10                   
+em = 2.1E7                    ef = 1.147                    
//***layout-dependent parasitics model parameter ***
+dmcg = 8.5E-8                 dmci = 8.5E-8                 dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** vth related  parameter ***
+vth0 = -0.369135+dvth0_p+vthmis_p      lvth0 = 4.367271E-9+dlvth0_p  wvth0 = 6.061205E-9+dwvth0_p  
+pvth0 = -3.871715E-16+dpvth0_p phin = 0                      k1 = 0.25                     
+k2 = -7.128531E-3             lk2 = -1.770246E-10           wk2 = -7.701441E-10           
+pk2 = -1.189732E-16           k3 = -1.700953                k3b = 1.200306                
+w0 = 1.585076E-7              lpe0 = 7.519925E-8            lpeb = 5.608072E-8            
+dvtp0 = 2.2E-6                dvtp1 = 0.2                   dvt0 = 0.20341                
+dvt1 = 0.95146                dvt2 = 0.01                   dvt0w = 0                     
+dvt1w = 5.366499E6            dvt2w = 0                     
//*** mobility related parameter ***
+u0 = 2.47139E-2+du0_p         lu0 = -4.235042E-10+dlu0_p    wu0 = 5.029246E-10+dwu0_p     
+pu0 = 2.12968E-17+dpu0_p      ua = 1.195233E-11             ub = 1.495572E-18             
+lub = 2.766144E-26            wub = 4.041856E-26            pub = -3.729918E-33           
+uc = 2.835787E-11             wuc = -1.637456E-18           ud = 0                        
+vsat = 1.25522E5+dvsat_p      lvsat = 1.651738E-3           wvsat = -4.554101E-3          
+pvsat = 2.732461E-10          a0 = 1E-3                     ags = 2.604403                
+wags = 8.642956E-8            b0 = 0                        b1 = 0                        
+keta = 0.076145               lketa = -1.38531E-8           wketa = -1.376189E-8          
+pketa = 1.122276E-15          a1 = 0                        a2 = 1                        
+rdsw = 327.6                  prwb = -0.249981              prwg = 0.25                   
+wr = 1                        
//*** subthreshold related parameter ***
+voff = -0.131916              lvoff = 5.303768E-9           wvoff = 5.559449E-9           
+pvoff = -5.016324E-16         voffl = -6.036214E-9          minv = 0                      
+nfactor = 0.511088            lnfactor = 2.816183E-8        wnfactor = -4.781791E-8       
+pnfactor = 6.586688E-16       eta0 = 3.11538E-2             etab = 0.247803               
+letab = -1.629918E-8          wetab = -2.66802E-8           petab = 1.600812E-15          
+dsub = 1.2725                 cit = 1E-4                    cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** output resistance related parameter ***
+pclm = 0.627258               pdiblc1 = 0                   pdiblc2 = 1.06974E-2          
+lpdiblc2 = -3.548114E-10      wpdiblc2 = -9.67633E-10       ppdiblc2 = 3.298003E-17       
+pdiblcb = 0                   drout = 0.962144              ldrout = 1.023288E-8          
+wdrout = 4.744888E-8          pdrout = -2.846933E-15        pscbe1 = 9.264E8              
+pscbe2 = 1E-20                pvag = 1.425                  delta = 0.02                  
+fprout = 390.234144           pdits = 5.042617E-3           pditsl = 100                  
+pditsd = 0                    alpha0 = 0                    alpha1 = 0.06                 
+beta0 = 13.5                  agidl = 9E-8                  bgidl = 3.404E9               
+cgidl = 0.5                   egidl = 0.15                  
//*** gate dielectric tunneling current ***
+aigbacc = 0.012               bigbacc = 3.49E-3             cigbacc = 0.131               
+nigbacc = 5.2                 aigbinv = 0.347               bigbinv = 0.0312              
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 1                   
+aigc = 7.12E-3                bigc = 6.31E-4                cigc = 0                      
+aigsd = 5.9E-3                bigsd = 2.48E-4               cigsd = 0.032                 
+dlcig = 2.52E-9               nigc = 2.28                   poxedge = 1                   
+pigcd = 2.28                  ntox = 1                      toxref = 3E-9                 
//*** capacitance parameter ***
+xpart = 1                     cgso = 3.1E-11+dcgso_p        cgdo = 3.1E-11+dcgdo_p        
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 1.18E-10                 clc = 1E-7                    cle = 0.6                     
+dlc = 0                       dwc = 0                       noff = 2.5                    
+voffcv = -0.0486              acde = 1.2                    moin = 8                      
+cgsl = 0.54E-10+dcgsl_p       cgdl = 0.54E-10+dcgdl_p       
//*** souce/drain junction diode model parameter **
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 1.51E-7                 jsws = 3.98E-13               
+jswgs = 2.47E-12              cjs = 9.98E-4+dcj_p           mjs = 0.34                    
+mjsws = 0.012                 cjsws = 6.21E-11+dcjsw_p      cjswgs = 2.53E-10+dcjswg_p    
+mjswgs = 0.86                 pbs = 0.75                    pbsws = 0.49                  
+pbswgs = 0.71                 
//** rf model related parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** stress effect related parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 2.86E-7                
+ku0 = 1E-7                    kvsat = -0.386                kvth0 = 2E-10                 
+tku0 = 0.24                   llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1.8                 wlodvth = 1                   lku0 = 1.871E-7               
+wku0 = 2.4E-7                 pku0 = -3.24E-14              lkvth0 = 2.4E-10              
+wkvth0 = 1.8E-10              pkvth0 = 0                    stk2 = 0                      
+lodk2 = 1.9                   steta0 = 0                    lodeta0 = 1                   
//*** temperature coefficient ***
+tnom = 25                     ute = -1.524                  kt1 = -0.229                  
+kt1l = 0                      kt2 = -0.01232                ua1 = 4.549E-9                
+ub1 = -5.441E-18              uc1 = -5E-11                  at = 4.00001E4                
+prt = 0                       njs = 1                       xtis = 3                      
+tpb = 1.9E-3                  tpbsw = 1.9E-3                tpbswg = 1.9E-3               
+tcj = 7.98E-4                 tcjsw = 2.4E-4                tcjswg = 4.77E-3              
//*** well proximity effect model parameters ***
+web = -220                    wec = -3E3                    kvth0we = -3.197498E-3        
+k2we = 3E-4                   ku0we = -3.482487E-3          scref = 1E-6                  
}

ends gpdk045_pmos1v
  


model nch bsim4 {
1:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n                   lmax = 1.1E-5-dxl_n                 wmin = 2.0E-6-dxw_n                   
+wmax = 1.1E-5-dxw_n                 
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0.0+dxl_n                
+xw = 0.0+dxw_n                
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.34925+dvth0_n        lvth0 = 0.0+dlvth0_n          wvth0 = 0.0+dwvth0_n          
+pvth0 = 0.0+dpvth0_n          phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.0152801+du0_n          lu0 = -2.636545E-10+dlu0_n    wu0 = -3.215249E-10+dwu0_n    
+pu0 = 7.659855E-16+dpu0_n     ua = -1.9203E-9               lua = -9.059977E-18           
+wua = 1.401586E-17            pua = -4.284537E-24           ub = 2.276039E-18             
+lub = -2.737235E-26           wub = -4.319124E-26           pub = 9.846961E-32            
+uc = 7.443076E-11             luc = -1.669235E-17           wuc = -1.649254E-17           
+puc = 3.331794E-23            ud = 0                        vsat = 137107.0+dvsat_n       
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.930529                 la0 = -2.066163E-6            ags = 1.062652                
+lags = 8.605063E-7            b0 = 0                        b1 = 0                        
+keta = -6.63214E-2            lketa = 4.616804E-8           wketa = 7.781602E-10          
+pketa = -7.780046E-15         a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.15529               lvoff = 2.424242E-9           wvoff = 3.082726E-9           
+pvoff = -4.838786E-15         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.980741            lnfactor = 2.278475E-7        wnfactor = 2.101514E-7        
+pnfactor = -4.547836E-13      eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.652665E-3         
+lpdiblc2 = -1.102969E-9       wpdiblc2 = 2.236938E-11       ppdiblc2 = -2.236491E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
2:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n                   lmax = 2.0E-6-dxl_n                   wmin = 2.0E-6-dxw_n                   
+wmax = 1.1E-5-dxw_n                 
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.348827+dvth0_n       lvth0 = 8.442663E-10+dlvth0_n wvth0 = -3.248163E-9+dwvth0_n 
+pvth0 = 6.48983E-15+dpvth0_n  phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.53763E-2+du0_n         lu0 = -4.559811E-10+dlu0_n    wu0 = -3.06025E-10+dwu0_n     
+pu0 = 7.350168E-16+dpu0_n     ua = -1.918445E-9             lua = -1.27667E-17            
+wua = 7.107477E-18            pua = 9.518418E-24            ub = 2.275016E-18             
+lub = -2.532801E-26           wub = -2.188103E-27           pub = 1.654534E-32            
+uc = 6.607623E-11             wuc = 1.831096E-19            ud = 0                        
+vsat = 1.37107E5+dvsat_n      lvsat = 0                     wvsat = 0                     
+pvsat = 0                     a0 = 0.230932                 la0 = 1.329631E-6             
+wa0 = 3.747559E-7             pa0 = -7.487623E-13           ags = 0.164079                
+lags = 2.655856E-6            wags = 1.170882E-7            pags = -2.339422E-13          
+b0 = 0                        b1 = 0                        keta = -2.29457E-2            
+lketa = -4.049659E-8          wketa = -6.200143E-9          pketa = 6.162604E-15          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.156085              lvoff = 4.011719E-9           wvoff = 3.69253E-9            
+pvoff = -6.057175E-15         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.963931            lnfactor = 2.614339E-7        wnfactor = 7.362414E-9        
+pnfactor = -4.961115E-14      eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.076934E-3         
+lpdiblc2 = 4.734049E-11       wpdiblc2 = 1.472775E-10       ppdiblc2 = -4.732155E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
3:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 5.0E-7-dxl_n                   lmax = 1.0E-6-dxl_n                   wmin = 2.0E-6-dxw_n                   
+wmax = 1.1E-5-dxw_n                 
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.352645+dvth0_n       lvth0 = -2.965664E-9+dlvth0_n wvth0 = 3.458363E-9+dwvth0_n  
+pvth0 = -2.032828E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.49678E-2+du0_n         lu0 = -4.831396E-11+dlu0_n    wu0 = 4.562986E-10+dwu0_n     
+pu0 = -2.57822E-17+dpu0_n     ua = -1.918037E-9             lua = -1.317425E-17           
+wua = -2.477865E-17           pua = 4.134077E-23            ub = 2.222816E-18             
+lub = 2.67682E-26             wub = 7.98867E-26             pub = -6.536532E-32           
+uc = 6.607623E-11             wuc = 1.831096E-19            ud = 0                        
+vsat = 1.37107E5+dvsat_n      lvsat = 0                     wvsat = 0                     
+pvsat = 0                     a0 = 1.426295                 la0 = 1.366587E-7             
+wa0 = -6.463353E-7            pa0 = 2.702867E-13            ags = 1.185611                
+lags = 1.636367E-6            wags = -2.593172E-7           pags = 1.417104E-13           
+b0 = 0                        b1 = 0                        keta = -6.35361E-2            
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.15272               lvoff = 6.530101E-10          wvoff = -3.353006E-9          
+pvoff = 9.742698E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.07151             lnfactor = 1.540699E-7        wnfactor = -9.169333E-8       
+pnfactor = 4.924649E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.15239E-3          
+lpdiblc2 = -2.79643E-11       wpdiblc2 = -6.069777E-10      ppdiblc2 = 2.795311E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
4:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-7-dxl_n                   lmax = 5.0E-7-dxl_n                   wmin = 2.0E-6-dxw_n                   
+wmax = 1.1E-5-dxw_n                 
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.346512+dvth0_n       lvth0 = 8.869664E-11+dlvth0_n wvth0 = 3.006781E-9+dwvth0_n  
+pvth0 = 2.160485E-17+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.49887E-2+du0_n         lu0 = -5.868444E-11+dlu0_n    wu0 = 4.724126E-10+dwu0_n     
+pu0 = -3.380697E-17+dpu0_n    ua = -1.943415E-9             lua = -5.355717E-19           
+wua = 6.168421E-17            pua = -1.717735E-24           ub = 2.268086E-18             
+lub = 4.223629E-27            wub = -5.176552E-26           pub = 1.974863E-34            
+uc = 6.095064E-11             luc = 2.552546E-18            wuc = 2.858476E-18            
+puc = -1.332332E-24           ud = 0                        vsat = 1.371068E5+dvsat_n     
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.117139                 la0 = -2.073816E-7            wa0 = -1.289706E-7            
+pa0 = 1.263912E-14            ags = 4.142833                lags = 1.636699E-7            
+wags = 2.338671E-8            pags = 9.238341E-16           b0 = 0                        
+b1 = 0                        keta = -6.84235E-2            lketa = 2.4402E-9             
+wketa = -2.518942E-11         a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.149693              lvoff = -8.543634E-10         wvoff = -1.512737E-9          
+pvoff = 5.78157E-17           voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.279392            lnfactor = 5.054459E-8        wnfactor = 6.666043E-9        
+pnfactor = 2.635179E-16       eta0 = 3.453491E-3            leta0 = -2.4402E-10           
+etab = -1.49631E-2            letab = -4.846381E-10         wetab = -2.347268E-8          
+petab = 1.168939E-14          dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 5.130311E-4         lpdiblc1 = -2.988006E-11      
+wpdiblc1 = -5.997613E-10      ppdiblc1 = 2.986811E-16       pdiblc2 = 8.131707E-3         
+lpdiblc2 = -1.766403E-11      wpdiblc2 = 8.259697E-10       ppdiblc2 = -4.340767E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
5:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 6.0E-8-dxl_n                   lmax = 1.0E-7-dxl_n                   wmin = 2.0E-6-dxw_n                   
+wmax = 1.1E-5-dxw_n                 
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.339782+dvth0_n       lvth0 = 7.482256E-10+dlvth0_n wvth0 = -2.878078E-10+dwvth0_n 
+pvth0 = 3.444745E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -3.244617E-3             lk2 = -8.712575E-10           wk2 = -6.880378E-9            
+pk2 = 6.74277E-16             k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.46581E-2+du0_n         lu0 = -2.628521E-11+dlu0_n    wu0 = 1.408238E-10+dwu0_n     
+pu0 = -1.311271E-18+dpu0_n    ua = -2.013531E-9             lua = 6.335764E-18            
+wua = 3.038181E-17            pua = 1.349901E-24            ub = 2.31846E-18              
+lub = -7.130189E-28           wub = -8.336451E-27           pub = -4.058562E-33           
+uc = 8.699702E-11             wuc = -1.073675E-17           ud = 0                        
+vsat = 1.37107E5+dvsat_n      lvsat = 0                     wvsat = 0                     
+pvsat = 0                     a0 = 1E-3                     ags = 5.812934                
+wags = 3.281358E-8            b0 = 0                        b1 = 0                        
+keta = -0.036288              lketa = -7.09079E-10          wketa = -7.235125E-8          
+pketa = 7.087954E-15          a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.157109              lvoff = -1.275907E-10         wvoff = -1.689437E-9          
+pvoff = 7.513231E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.545726            lnfactor = 1.224439E-7        wnfactor = 2.845656E-9        
+pnfactor = 6.379158E-16       eta0 = 9.63491E-4             etab = -2.30596E-2            
+letab = 3.088173E-10          wetab = 2.105913E-7           petab = -1.124888E-14         
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = -5.88954E-3         lpdiblc1 = 5.975719E-10       
+wpdiblc1 = 1.877094E-8        ppdiblc1 = -1.599648E-15      pdiblc2 = 4.317518E-3         
+lpdiblc2 = 3.561265E-10       wpdiblc2 = 6.516453E-9        ppdiblc2 = -9.91744E-16       
+pdiblcb = 1                   drout = 0.752025              ldrout = -1.881841E-8         
+wdrout = -3.832811E-7         pdrout = 3.756155E-14         pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
6:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 4.0E-8                   lmax = 6.0E-8-dxl_n                   wmin = 2.0E-6-dxw_n                   
+wmax = 1.1E-5-dxw_n                 
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.344879+dvth0_n       lvth0 = 4.526312E-10+dlvth0_n wvth0 = 4.5947E-9+dwvth0_n    
+pvth0 = 6.12891E-17+dpvth0_n  phin = 0                      k1 = 0.30264                  
+k2 = -1.64348E-2              lk2 = -1.062293E-10           wk2 = -1.356298E-8            
+pk2 = 1.061868E-15            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.014758+du0_n           lu0 = -3.207916E-11+dlu0_n    wu0 = 8.87942E-9+dwu0_n       
+pu0 = -5.081499E-16+dpu0_n    ua = -2.01495E-9              lua = 6.41809E-18             
+wua = 8.840299E-16            pua = -4.816169E-23           ub = 2.3344E-18               
+lub = -1.637544E-27           wub = -2.323731E-25           pub = 8.935566E-33            
+uc = 8.699702E-11             wuc = -1.073675E-17           ud = 0                        
+vsat = 1.143112E5+dvsat_n     lvsat = 1.322158E-3           wvsat = 1.89544E-2            
+pvsat = -1.099356E-9          a0 = 1E-3                     ags = 5.812934                
+lags = 0                      wags = 3.281358E-8            pags = 0                      
+b0 = 0                        b1 = 0                        keta = -4.85135E-2            
+wketa = 4.985485E-8           a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.158578              lvoff = -4.238022E-11         wvoff = 2.690779E-9           
+pvoff = -1.789202E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.2338              lnfactor = 1.405356E-7        wnfactor = 1.220565E-9        
+pnfactor = 7.321712E-16       eta0 = 9.63491E-4             etab = -1.33266E-2            
+letab = -2.556967E-10         wetab = 4.495715E-8           petab = -1.642097E-15         
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 5.91146E-3          lpdiblc1 = -8.688609E-11      
+wpdiblc1 = -3.226781E-8       ppdiblc1 = 1.3606E-15         pdiblc2 = 7.963446E-3         
+lpdiblc2 = 1.446627E-10       wpdiblc2 = -1.146998E-8       ppdiblc2 = 5.146883E-17       
+pdiblcb = 1                   drout = 0.587767              ldrout = -9.291467E-9         
+wdrout = 2.01152E-7           pdrout = 3.664429E-15         pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
7:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n                   lmax = 1.1E-5-dxl_n                 wmin = 1.0E-6-dxw_n                   
+wmax = 2.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.34925+dvth0_n        lvth0 = 0+dlvth0_n            wvth0 = 0+dwvth0_n            
+pvth0 = 0+dpvth0_n            phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.52058E-2+du0_n         lu0 = 8.653106E-11+dlu0_n     wu0 = -1.732986E-10+dwu0_n    
+pu0 = 6.701504E-17+dpu0_n     ua = -1.912987E-9             lua = -1.411386E-17           
+wua = -5.804167E-19           pua = 5.803006E-24            ub = 2.253887E-18             
+lub = 2.709183E-26            wub = 1.024294E-27            pub = -1.024089E-32           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.930672                 la0 = -2.067598E-6            wa0 = -2.864845E-10           
+pa0 = 2.864272E-15            ags = 1.062652                lags = 8.605063E-7            
+b0 = 0                        b1 = 0                        keta = -6.58719E-2            
+lketa = 4.167334E-8           wketa = -1.191617E-10         pketa = 1.191378E-15          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.153746              voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.086027            eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.662305E-3         
+lpdiblc2 = -1.199355E-9       wpdiblc2 = 3.127001E-12       ppdiblc2 = -3.126376E-17      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
8:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n                   lmax = 2.0E-6-dxl_n                   wmin = 1.0E-6-dxw_n                   
+wmax = 2.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.347201+dvth0_n       lvth0 = 4.093698E-9+dlvth0_n  wvth0 = 0+dwvth0_n            
+pvth0 = 3.964112E-18+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.52757E-2+du0_n         lu0 = -5.317929E-11+dlu0_n    wu0 = -1.052352E-10+dwu0_n    
+pu0 = -6.897555E-17+dpu0_n    ua = -1.911737E-9             lua = -1.661135E-17           
+wua = -6.280791E-18           pua = 1.719235E-23            ub = 2.273523E-18             
+lub = -1.214122E-26           wub = 7.913656E-28            pub = -9.7755E-33             
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.572041                 la0 = 6.469475E-7             wa0 = -3.060974E-7            
+pa0 = 6.138744E-13            ags = 0.261003                lags = 2.462202E-6            
+wags = -7.637165E-8           pags = 1.525906E-13           b0 = 0                        
+b1 = 0                        keta = -2.75228E-2            lketa = -3.494802E-8          
+wketa = 2.935746E-9           pketa = -4.912327E-15         a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.15424               lvoff = 9.869921E-10          wvoff = 9.9202E-12            
+pvoff = -1.982056E-17         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.980141            lnfactor = 2.115606E-7        wnfactor = -2.499295E-8       
+pnfactor = 4.993592E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.322699E-3         
+lpdiblc2 = -5.208203E-10      wpdiblc2 = -3.432679E-10      ppdiblc2 = 6.608333E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
9:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 5.0E-7-dxl_n                   lmax = 1.0E-6-dxl_n                   wmin = 1.0E-6-dxw_n                   
+wmax = 2.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.354115+dvth0_n       lvth0 = -2.80614E-9+dlvth0_n  wvth0 = 5.247249E-10+dwvth0_n 
+pvth0 = -5.216914E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.015143+du0_n           lu0 = 7.925464E-11+dlu0_n     wu0 = 1.066221E-10+dwu0_n     
+pu0 = -2.804091E-16+dpu0_n    ua = -1.959977E-9             lua = 3.153198E-17            
+wua = 5.893485E-17            pua = -4.789285E-23           ub = 2.285082E-18             
+lub = -2.367677E-26           wub = -4.439737E-26           pub = 3.532286E-32            
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.852892                 la0 = 3.666576E-7             wa0 = 4.981766E-7             
+pa0 = -1.88791E-13            ags = 0.896741                lags = 1.827735E-6            
+wags = 3.172668E-7            pags = -2.402606E-13          b0 = 0                        
+b1 = 0                        keta = -6.25409E-2            wketa = -1.986426E-9          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.15453               lvoff = 1.276756E-9           wvoff = 2.613287E-10          
+pvoff = -2.707262E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.9986              lnfactor = 1.931386E-7        wnfactor = 5.383515E-8        
+pnfactor = -2.873453E-14      eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 7.576672E-3         
+lpdiblc2 = 2.237144E-10       wpdiblc2 = 5.421558E-10       ppdiblc2 = -2.228195E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
10:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-7-dxl_n                   lmax = 5.0E-7-dxl_n                   wmin = 1.0E-6-dxw_n                   
+wmax = 2.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.348623+dvth0_n       lvth0 = -7.119331E-11+dlvth0_n wvth0 = -1.207173E-9+dwvth0_n 
+pvth0 = 3.407937E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -0.012135                k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.53686E-2+du0_n         lu0 = -3.306481E-11+dlu0_n    wu0 = -2.858787E-10+dwu0_n    
+pu0 = -8.494375E-17+dpu0_n    ua = -1.899401E-9             lua = 1.365183E-18            
+wua = -2.616799E-17           pua = -5.511642E-24           ub = 2.226137E-18             
+lub = 5.677783E-27            wub = 3.19638E-26             pub = -2.705005E-33           
+uc = 6.099261E-11             luc = 2.57733E-18             wuc = 2.774701E-18            
+puc = -1.381801E-24           ud = 0                        vsat = 1.371068E5+dvsat_n     
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.97825                  la0 = -1.937705E-7            wa0 = 1.482523E-7             
+pa0 = -1.452873E-14           ags = 4.231225                lags = 1.671619E-7            
+wags = -1.530432E-7           pags = -6.046239E-15          b0 = 0                        
+b1 = 0                        keta = -5.16684E-2            lketa = -5.414518E-9          
+wketa = -3.346839E-8          pketa = 1.567802E-14          a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.150353              lvoff = -8.036452E-10         wvoff = -1.951138E-10         
+pvoff = -4.341785E-17         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.284525            lnfactor = 5.074758E-8        wnfactor = -3.580258E-9       
+pnfactor = -1.416538E-16      eta0 = 3.941531E-3            leta0 = -4.870639E-10         
+weta0 = -9.741278E-10         peta0 = 4.851157E-16          etab = -0.026723              
+letab = 5.371771E-9           dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = -2.697E-5           lpdiblc1 = 2.390405E-10       
+wpdiblc1 = 4.78081E-10        ppdiblc1 = -2.380843E-16      pdiblc2 = 8.238968E-3         
+lpdiblc2 = -1.061089E-10      wpdiblc2 = 6.118768E-10       ppdiblc2 = -2.575406E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
11:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 6.0E-8-dxl_n                   lmax = 1.0E-7-dxl_n                   wmin = 1.0E-6-dxw_n                   
+wmax = 2.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.338826+dvth0_n       lvth0 = 8.889634E-10+dlvth0_n wvth0 = 1.621724E-9+dwvth0_n  
+pvth0 = 6.356184E-17+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.270173E-3             lk2 = -1.064753E-9            wk2 = -1.082137E-8            
+pk2 = 1.060494E-15            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.43509E-2+du0_n         lu0 = 6.666684E-11+dlu0_n     wu0 = 7.539153E-10+dwu0_n     
+pu0 = -1.868436E-16+dpu0_n    ua = -2.031672E-9             lua = 1.432769E-17            
+wua = 6.659068E-17            pua = -1.460199E-23           ub = 2.303017E-18             
+lub = -1.856416E-27           wub = 2.248764E-26            pub = -1.776342E-33           
+uc = 1.007963E-10             luc = -1.323435E-18           wuc = -3.828017E-17           
+puc = 2.641576E-24            ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1E-3                     ags = 5.936959                wags = -2.147395E-7           
+b0 = 0                        b1 = 0                        keta = -0.164803              
+lketa = 5.672632E-9           wketa = 1.841638E-7           pketa = -5.649941E-15         
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.156994              lvoff = -1.527893E-10         wvoff = -1.918038E-9          
+pvoff = 1.254287E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.547918            lnfactor = 1.229351E-7        wnfactor = -1.529083E-9       
+pnfactor = -3.42669E-16       eta0 = -5.072269E-3           leta0 = 3.962885E-10          
+weta0 = 1.204738E-8           peta0 = -7.909918E-16         etab = 9.25777E-2             
+letab = -6.319699E-9          wetab = -2.022081E-8          petab = 1.98164E-15           
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 7.321613E-3         lpdiblc1 = -4.811206E-10      
+wpdiblc1 = -7.598517E-9       ppdiblc1 = 5.534222E-16       pdiblc2 = 7.799202E-3         
+lpdiblc2 = -6.301194E-11      wpdiblc2 = -4.329896E-10      ppdiblc2 = -1.551437E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
12:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 4.0E-8                   lmax = 6.0E-8-dxl_n                   wmin = 1.0E-6-dxw_n                   
+wmax = 2.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.354254+dvth0_n       lvth0 = -5.87053E-12+dlvth0_n wvth0 = -1.411788E-8+dwvth0_n 
+pvth0 = 9.764586E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -2.10085E-2              lk2 = 8.007246E-11            wk2 = -4.433707E-9            
+pk2 = 6.900097E-16            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 2.32553E-2+du0_n         lu0 = -4.497874E-10+dlu0_n    wu0 = -8.081245E-9+dwu0_n     
+pu0 = 3.255957E-16+dpu0_n     ua = -1.204502E-9             lua = -3.364816E-17           
+wua = -7.336254E-16           pua = 3.181054E-23            ub = 2.13422E-18              
+lub = 7.933776E-27            wub = 1.67185E-25             pub = -1.016879E-32           
+uc = 7.797849E-11             wuc = 7.26425E-18             ud = 0                        
+vsat = 1.238074E5+dvsat_n     lvsat = 7.71378E-4            wvsat = -2.190794E-6          
+pvsat = 1.27066E-13           a0 = 1E-3                     ags = 5.936959                
+wags = -2.147395E-7           b0 = 0                        b1 = 0                        
+keta = -6.69986E-2            wketa = 8.675105E-8           a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.156783              lvoff = -1.650571E-10         wvoff = -8.924204E-10         
+pvoff = 6.594289E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.234741            lnfactor = 1.410994E-7        wnfactor = -6.570393E-10      
+pnfactor = -3.932475E-16      eta0 = 1.760291E-3            weta0 = -1.590413E-9          
+etab = -1.13964E-2            letab = -2.891974E-10         wetab = 4.110453E-8           
+petab = -1.57523E-15          dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = -1.01684E-2         lpdiblc1 = 5.332986E-10       
+wpdiblc1 = -1.724596E-10      ppdiblc1 = 1.227109E-16       pdiblc2 = 2.88314E-3          
+lpdiblc2 = 2.221197E-10       wpdiblc2 = -1.329686E-9       ppdiblc2 = -1.031353E-16      
+pdiblcb = 1                   drout = 0.767707              ldrout = -1.204703E-8         
+wdrout = -1.580091E-7         pdrout = 9.164528E-15         pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
13:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n                   lmax = 1.1E-5-dxl_n                 wmin = 5.0E-7-dxw_n                   
+wmax = 1.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.34925+dvth0_n        lvth0 = 0+dlvth0_n            wvth0 = 0+dwvth0_n            
+pvth0 = 0+dpvth0_n            phin = 0                      k1 = 0.30264                  
+k2 = -1.37822E-2              wk2 = 1.640627E-9             k3 = -7.284535                
+k3b = 2.454986                w0 = 8.190018E-8              lpe0 = 6.610138E-8            
+lpeb = 2.000404E-8            dvtp0 = 2.36094E-6            dvtp1 = 4.5                   
+dvt0 = 0.236381               dvt1 = 0.537442               dvt2 = 5.56679E-2             
+dvt0w = 0                     dvt1w = 0                     dvt2w = 0                     
+vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.51313E-2+du0_n         lu0 = -5.040825E-10+dlu0_n    wu0 = -9.913281E-11+dwu0_n    
+pu0 = 6.552661E-16+dpu0_n     ua = -1.898517E-9             lua = -1.255994E-16           
+wua = -1.499256E-17           pua = 1.168426E-22            ub = 2.219652E-18             
+lub = 1.417534E-25            wub = 3.512221E-26            pub = -1.244438E-31           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.040554                 la0 = -3.166193E-6            wa0 = -1.097284E-7            
+pa0 = 1.097065E-12            ags = 1.062652                lags = 8.605063E-7            
+b0 = 0                        b1 = 0                        keta = -6.64279E-2            
+lketa = 4.723253E-8           wketa = 4.346448E-10          pketa = -4.345579E-15         
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.153675              lvoff = -7.08429E-10          wvoff = -7.057364E-11         
+pvoff = 7.055953E-16          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.086027            eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.708636E-3         
+lpdiblc2 = -1.662569E-9       wpdiblc2 = -4.301834E-11      ppdiblc2 = 4.300973E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
14:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n                   lmax = 2.0E-6-dxl_n                   wmin = 5.0E-7-dxw_n                   
+wmax = 1.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.346552+dvth0_n       lvth0 = 5.391324E-9+dlvth0_n  wvth0 = 6.448806E-10+dwvth0_n 
+pvth0 = -1.288471E-15+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.57781E-2              lk2 = 3.987753E-9             wk2 = 3.628516E-9             
+pk2 = -3.971802E-15           k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.49573E-2+du0_n         lu0 = -1.562565E-10+dlu0_n    wu0 = 2.119667E-10+dwu0_n     
+pu0 = 3.368939E-17+dpu0_n     ua = -1.971699E-9             lua = 2.061848E-17            
+wua = 5.344148E-17            pua = -1.988856E-23           ub = 2.318703E-18             
+lub = -5.615056E-26           wub = -4.420794E-26           pub = 3.405781E-32            
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = -0.40514                 la0 = 1.720302E-6             wa0 = 6.671745E-7             
+pa0 = -4.55187E-13            ags = 2.21022E-2              lags = 2.939525E-6            
+wags = 1.615732E-7            pags = -3.228232E-13          b0 = 0                        
+b1 = 0                        keta = -0.022828              lketa = -3.988008E-8          
+wketa = -1.74032E-9           a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.154994              lvoff = 1.926447E-9           wvoff = 7.608143E-10          
+pvoff = -9.555178E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.943029            lnfactor = 2.857106E-7        wnfactor = 1.197072E-8        
+pnfactor = -2.39175E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 7.830016E-3         
+lpdiblc2 = 9.291504E-11       wpdiblc2 = 1.474443E-10       ppdiblc2 = 4.955296E-17       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
15:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 5.0E-7-dxl_n                   lmax = 1.0E-6-dxl_n                   wmin = 5.0E-7-dxw_n                   
+wmax = 1.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.356799+dvth0_n       lvth0 = -4.835634E-9+dlvth0_n wvth0 = -2.148863E-9+dwvth0_n 
+pvth0 = 1.499685E-15+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.17823E-2              wk2 = -3.512454E-10           k3 = -7.284535                
+k3b = 2.454986                w0 = 8.190018E-8              lpe0 = 6.610138E-8            
+lpeb = 2.000404E-8            dvtp0 = 2.36094E-6            dvtp1 = 4.5                   
+dvt0 = 0.236381               dvt1 = 0.537442               dvt2 = 5.56679E-2             
+dvt0w = 0                     dvt1w = 0                     dvt2w = 0                     
+vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.55148E-2+du0_n         lu0 = -7.126632E-10+dlu0_n    wu0 = -2.636362E-10+dwu0_n    
+pu0 = 5.08341E-16+dpu0_n      ua = -1.871537E-9             lua = -7.934329E-17           
+wua = -2.915118E-17           pua = 6.253891E-23            ub = 2.210337E-18             
+lub = 5.19993E-26             wub = 3.00489E-26             pub = -4.005052E-32           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.941253                 la0 = 3.766023E-7             wa0 = 4.101694E-7             
+pa0 = -1.986959E-13           ags = 1.534856                lags = 1.429796E-6            
+wags = -3.182958E-7           pags = 1.56086E-13            b0 = 0                        
+b1 = 0                        keta = -0.062788              wketa = -1.74032E-9           
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.15423               lvoff = 1.163697E-9           wvoff = -3.818151E-11         
+pvoff = -1.5812E-16           voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.067339            lnfactor = 1.61649E-7         wnfactor = -1.462909E-8       
+pnfactor = 2.629113E-15       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 7.664712E-3         
+lpdiblc2 = 2.578881E-10       wpdiblc2 = 4.544679E-10       ppdiblc2 = -2.568566E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
16:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-7-dxl_n                   lmax = 5.0E-7-dxl_n                   wmin = 5.0E-7-dxw_n                   
+wmax = 1.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.347058+dvth0_n       lvth0 = 1.546897E-11+dlvth0_n wvth0 = 3.515467E-10+dwvth0_n 
+pvth0 = 2.544806E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.17823E-2              wk2 = -3.512454E-10           k3 = -7.284535                
+k3b = 2.454986                w0 = 8.190018E-8              lpe0 = 6.610138E-8            
+lpeb = 2.000404E-8            dvtp0 = 2.36094E-6            dvtp1 = 4.5                   
+dvt0 = 0.236381               dvt1 = 0.537442               dvt2 = 5.56679E-2             
+dvt0w = 0                     dvt1w = 0                     dvt2w = 0                     
+vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.43396E-2+du0_n         lu0 = -1.27403E-10+dlu0_n     wu0 = 7.390222E-10+dwu0_n     
+pu0 = 9.017124E-18+dpu0_n     ua = -2.014187E-9             lua = -8.303839E-18           
+wua = 8.815847E-17            pua = 4.118704E-24            ub = 2.296589E-18             
+lub = 9.045685E-27            wub = -3.820628E-26           pub = -6.059435E-33           
+uc = 6.259793E-11             luc = 1.77788E-18             wuc = 1.175801E-18            
+puc = -5.855489E-25           ud = 0                        vsat = 1.371068E5+dvsat_n     
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 2.113121                 la0 = -2.069878E-7            wa0 = 1.392104E-8             
+pa0 = -1.364262E-15           ags = 4.082098                lags = 1.612703E-7            
+wags = -4.512233E-9           pags = -1.781726E-16          b0 = 0                        
+b1 = 0                        keta = -0.099233              lketa = 1.814964E-8           
+wketa = 1.390603E-8           pketa = -7.79188E-15          a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.150151              lvoff = -8.673291E-10         wvoff = -3.958748E-10         
+pvoff = 2.001126E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.289628            lnfactor = 5.094885E-8        wnfactor = -8.662758E-9       
+pnfactor = -3.421203E-16      eta0 = 2.963491E-3            etab = -0.026723              
+letab = 5.371771E-9           dsub = 0.422235               cit = 7.212E-4                
+cdsc = 0                      cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.873928E-3         
+lpdiblc2 = -3.443013E-10      wpdiblc2 = -2.054318E-11      ppdiblc2 = -2.030107E-17      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
17:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 6.0E-8-dxl_n                   lmax = 1.0E-7-dxl_n                   wmin = 5.0E-7-dxw_n                   
+wmax = 1.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.340007+dvth0_n       lvth0 = 7.065178E-10+dlvth0_n wvth0 = 4.454542E-10+dwvth0_n 
+pvth0 = 2.452777E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -8.371754E-3             lk2 = -3.342378E-10           wk2 = -3.748193E-9            
+pk2 = 3.329009E-16            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.46604E-2+du0_n         lu0 = -1.588462E-10+dlu0_n    wu0 = 4.456518E-10+dwu0_n     
+pu0 = 3.776742E-17+dpu0_n     ua = -2.067541E-9             lua = -3.075097E-18           
+wua = 1.023168E-16            pua = 2.731189E-24            ub = 2.42677E-18              
+lub = -3.712065E-27           wub = -1.007708E-25           pub = 7.188447E-35            
+uc = 6.078779E-11             luc = 1.955274E-18            wuc = 1.568338E-18            
+puc = -6.240175E-25           ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1E-3                     ags = 5.727713                wags = -6.330321E-9           
+b0 = 0                        b1 = 0                        keta = 0.114735               
+lketa = -2.819264E-9          wketa = -9.425588E-8          pketa = 2.807987E-15          
+a1 = 0                        a2 = 1                        rdsw = 100.002354             
+prwb = 0                      prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.158952              lvoff = -4.866641E-12         wvoff = 3.181463E-11          
+pvoff = -2.19023E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.550091            lnfactor = 1.234235E-7        wnfactor = -3.694005E-9       
+pnfactor = -8.290581E-16      eta0 = 6.788326E-3            leta0 = -3.748338E-10         
+weta0 = 2.342248E-10          peta0 = -2.295403E-17         etab = 0.116107               
+letab = -8.625562E-9          wetab = -4.365591E-8          petab = 4.278279E-15          
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = -6.12381E-4         lpdiblc1 = 1.484522E-10       
+wpdiblc1 = 3.03741E-10        ppdiblc1 = -7.363231E-17      pdiblc2 = 2.757225E-3         
+lpdiblc2 = 2.551356E-10       wpdiblc2 = 4.58882E-9         ppdiblc2 = -4.720187E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
18:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 4.0E-8                   lmax = 6.0E-8-dxl_n                   wmin = 5.0E-7-dxw_n                   
+wmax = 1.0E-6-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.346779+dvth0_n       lvth0 = 3.136908E-10+dlvth0_n wvth0 = -6.673474E-9+dwvth0_n 
+pvth0 = 6.581755E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.64376E-2              lk2 = 1.335793E-10            wk2 = -8.9864E-9              
+pk2 = 6.367169E-16            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.52269E-2+du0_n         lu0 = -1.917E-10+dlu0_n       wu0 = -8.492135E-11+dwu0_n    
+pu0 = 6.854067E-17+dpu0_n     ua = -1.963803E-9             lua = -9.091916E-18           
+wua = 2.263858E-17            pua = 7.352525E-24            ub = 2.369009E-18             
+lub = -3.619039E-28           wub = -6.66643E-26            pub = -1.906291E-33           
+uc = 1.268636E-10             luc = -1.877124E-18           wuc = -4.142533E-17           
+puc = 1.869615E-24            ud = 0                        vsat = 1.207921E5+dvsat_n     
+lvsat = 9.462655E-4           wvsat = 3.003242E-3           pvsat = -1.74188E-10          
+a0 = 1E-3                     ags = 5.727713                wags = -6.330321E-9           
+b0 = 0                        b1 = 0                        keta = 6.61273E-2             
+wketa = -4.584231E-8          a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.157691              lvoff = -7.796959E-11         wvoff = 1.274561E-11          
+pvoff = -2.07963E-17          voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.23567             lnfactor = 1.416599E-7        wnfactor = -1.582728E-9       
+pnfactor = -9.515122E-16      eta0 = 0                      etab = -5.13546E-2            
+letab = 1.087207E-9           wetab = 8.090284E-8           petab = -2.946129E-15         
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = -1.16079E-2         lpdiblc1 = 7.861951E-10       
+wpdiblc1 = 1.261355E-9        ppdiblc1 = -1.291739E-16      pdiblc2 = 3.083844E-3         
+lpdiblc2 = 2.361917E-10       wpdiblc2 = -1.529587E-9       ppdiblc2 = -1.171511E-16      
+pdiblcb = 1                   drout = 0.492949              ldrout = 3.888975E-9          
+wdrout = 1.156505E-7          pdrout = -6.707731E-15        pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
19:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 2.0E-6-dxl_n                   lmax = 1.1E-5-dxl_n                 wmin = 3.0E-7-dxw_n                   
+wmax = 5.0E-7-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.34925+dvth0_n        lvth0 = 0+dlvth0_n            wvth0 = 0+dwvth0_n            
+pvth0 = 0+dpvth0_n            phin = 0                      k1 = 0.30264                  
+k2 = -1.04745E-2              k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 1.49116E-2+du0_n         lu0 = 2.28083E-9+dlu0_n       wu0 = 9.85574E-12+dwu0_n      
+pu0 = -7.260506E-16+dpu0_n    ua = -1.946422E-9             lua = 2.867106E-16            
+wua = 8.768067E-18            pua = -8.766314E-23           ub = 2.288411E-18             
+lub = -2.348348E-25           wub = 1.017804E-27            pub = 6.234393E-32            
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 1.812026                 la0 = -8.813739E-7            wa0 = 3.621262E-9             
+pa0 = -3.620538E-14           ags = 1.130666                lags = 9.155813E-7            
+wags = -3.373463E-8           pags = -2.731717E-14          b0 = 0                        
+b1 = 0                        keta = -6.38539E-2            lketa = 2.149758E-8           
+wketa = -8.420645E-10         pketa = 8.41896E-15           a1 = 0                        
+a2 = 1                        rdsw = 100.002354             prwb = 0                      
+prwg = 0                      wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.154478              lvoff = 1.771073E-9           wvoff = 3.277142E-10          
+pvoff = -5.242375E-16         voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 1.086027            eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 8.645462E-3         
+lpdiblc2 = -1.030951E-9       wpdiblc2 = -1.168385E-11      ppdiblc2 = 1.168151E-16       
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
20:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 1.0E-6-dxl_n                   lmax = 2.0E-6-dxl_n                   wmin = 3.0E-7-dxw_n                   
+wmax = 5.0E-7-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.347226+dvth0_n       lvth0 = 4.044877E-9+dlvth0_n  wvth0 = 3.106274E-10+dwvth0_n 
+pvth0 = -6.206336E-16+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -5.484819E-3             lk2 = -9.969382E-9            wk2 = -1.476945E-9            
+pk2 = 2.950937E-15            k3 = -7.284535                k3b = 2.454986                
+w0 = 8.190018E-8              lpe0 = 6.610138E-8            lpeb = 2.000404E-8            
+dvtp0 = 2.36094E-6            dvtp1 = 4.5                   dvt0 = 0.236381               
+dvt1 = 0.537442               dvt2 = 5.56679E-2             dvt0w = 0                     
+dvt1w = 0                     dvt2w = 0                     vfbsdoff = 0.02               
//*** Mobility Related Parameter ***
+u0 = 0.016115+du0_n           lu0 = -1.234528E-10+dlu0_n    wu0 = -3.62251E-10+dwu0_n     
+pu0 = 1.741873E-17+dpu0_n     ua = -1.781269E-9             lua = -4.32655E-17            
+wua = -4.101223E-17           pua = 1.179789E-23            ub = 2.155343E-18             
+lub = 3.103564E-26            wub = 3.681885E-26            pub = -9.186548E-33           
+uc = 6.616797E-11             ud = 0                        vsat = 1.37107E5+dvsat_n      
+lvsat = 0                     wvsat = 0                     pvsat = 0                     
+a0 = 0.880942                 la0 = 9.789311E-7             wa0 = 2.927767E-8             
+pa0 = -8.746689E-14           ags = 0.478301                lags = 2.219005E-6            
+wags = -6.470165E-8           pags = 3.455495E-14           b0 = 0                        
+b1 = 0                        keta = -3.31343E-2            lketa = -3.988008E-8          
+wketa = 3.371629E-9           a1 = 0                        a2 = 1                        
+rdsw = 100.002354             prwb = 0                      prwg = 0                      
+wr = 1                        
//*** Subthreshold Related Parameter ***
+voff = -0.152723              lvoff = -1.735262E-9          wvoff = -3.654426E-10         
+pvoff = 8.6069E-16            voffl = -3.595178E-9          minv = -0.15                  
+nfactor = 0.988391            lnfactor = 1.950763E-7        wnfactor = -1.05291E-8        
+pnfactor = 2.103714E-14       eta0 = 2.963491E-3            etab = -1.59363E-2            
+dsub = 0.422235               cit = 7.212E-4                cdsc = 0                      
+cdscb = 0                     cdscd = 0                     
//*** Output Resistance Related Parameter ***
+pclm = 1.441266               pdiblc1 = 4.53031E-4          pdiblc2 = 7.890134E-3         
+lpdiblc2 = 4.781941E-10       wpdiblc2 = 1.176257E-10       ppdiblc2 = -1.415454E-16      
+pdiblcb = 1                   drout = 0.56                  pscbe1 = 1E9                  
+pscbe2 = 1E-20                pvag = 1.2                    delta = 7.595625E-3           
+fprout = 300                  pdits = 0                     pditsl = 0                    
+pditsd = 0                    alpha0 = 2E-10                alpha1 = 0.01                 
+beta0 = 6.4                   agidl = 2.1505E-7             bgidl = 2.1392E9              
+cgidl = 0.22                  egidl = 0.29734               
//*** Gate Dielectric Tunneling Current ***
+aigbacc = 0.02                bigbacc = 2.47E-3             cigbacc = 0.3325              
+nigbacc = 10                  aigbinv = 0.0158              bigbinv = 4.893E-3            
+cigbinv = 6.1E-3              eigbinv = 1.1                 nigbinv = 10                  
+aigc = 0.0112                 bigc = 1.392E-3               cigc = 6.22E-4                
+aigsd = 0.0106                bigsd = 1.235E-3              cigsd = 0.07                  
+dlcig = 2.48E-9               nigc = 3.07                   poxedge = 1                   
+pigcd = 2.591                 ntox = 1                      toxref = 3E-9                 
//*** Flicker Noise Model Parameter ***
+noia = 2.6E42                 noib = 1.61E21                noic = 3E8                    
+em = 1E6                      ef = 0.94                     lintnoi = -5E-9               
//*** Capacitance Parameter ***
+xpart = 1                     cgso = 5.53E-11+dcgso_n       cgdo = 5.53E-11+dcgdo_n       
+cgbo = 0                      ckappas = 0.6                 ckappad = 0.6                 
+cf = 8.13E-11                 clc = 1.04E-7                 cle = 0.6                     
+dlc = 0                 dwc = 0                       noff = 2.96                   
+voffcv = -0.12                acde = 1                      moin = 5.67                   
+cgsl = 1.71E-11+dcgsl_n       cgdl = 1.71E-11+dcgdl_n       
//*** Souce/Drain Junction Diode Model Parameter ***
+ijthsrev = 0.01               ijthsfwd = 0.01               xjbvs = 1                     
+bvs = 10                      jss = 2.1E-7                  jsws = 3.4E-13                
+jswgs = 1.2E-12               cjs = 8.61E-4+dcj_n           mjs = 0.264                   
+mjsws = 0.011                 cjsws = 4.87E-11+dcjsw_n      cjswgs = 2.56E-10+dcjswg_n    
+mjswgs = 0.511                pbs = 0.511                   pbsws = 0.786                 
+pbswgs = 0.464                
//** RF Model Related Parameter ***
+xrcrg1 = 12                   xrcrg2 = 1                    rbpb = 50                     
+rbpd = 50                     rbps = 50                     rbdb = 50                     
+rbsb = 50                     gbmin = 1E-12                 
//*** Temperature coefficient ***
+tnom = 25                     ute = -1                      kt1 = -0.18098                
+kt1l = 0                      kt2 = -0.036                  ua1 = 1.04E-9                 
+ub1 = -4.64E-19               uc1 = 8.71E-11                at = 1.4E5                    
+prt = 0                       njs = 1                       njd = 1                       
+xtis = 3                      xtid = 3                      tpb = 1.1E-3                  
+tpbsw = 1.9E-3                tpbswg = 1E-3                 tcj = 6.52E-4                 
+tcjsw = 3.57E-4               tcjswg = 1.5E-3               tvoff = 2.2428E-3             
+tvfbsdoff = 0.022             
//*** Stress Effect Related Parameter ***
+saref = 6.1E-7                sbref = 6.1E-7                wlod = 1.37E-7                
+ku0 = -3.471E-8               kvsat = 0.342                 kvth0 = 2.461E-9              
+tku0 = 0.097                  llodku0 = 1                   wlodku0 = 1                   
+llodvth = 1                   wlodvth = 1                   lku0 = 1.23E-8                
+wku0 = 9.96E-8                pku0 = 4.6E-14                lkvth0 = -2.421E-11           
+wkvth0 = 0                    pkvth0 = 0                    stk2 = 3.87E-10               
+lodk2 = 0.5                   steta0 = 0                    lodeta0 = 1                   
//*** Well Proximity Effect Model Parameters ***
+web = -210                    wec = -3.51E3                 kvth0we = 3.270022E-3         
+k2we = 1.50195E-3             ku0we = -3.001501E-3          scref = 1E-6                  
21:type=n  minr=1e-60
//*** Flag Parameter ***
+level = 54                    version = 4.3                 binunit = 2                   
+mobmod = 0                    capmod = 2                    rdsmod = 0                    
+igcmod = 1                    igbmod = 1                    rbodymod = 0                  
+trnqsmod = 0                  acnqsmod = 0                  fnoimod = 1                   
+tnoimod = 0                   diomod = 1                    tempmod = 0                   
+permod = 1                    rgatemod = 0                  wpemod = 1                    
//*** Geometry Range Parameter ***
+lmin = 5.0E-7-dxl_n                   lmax = 1.0E-6-dxl_n                   wmin = 3.0E-7-dxw_n                   
+wmax = 5.0E-7-dxw_n                   
//*** Process Parameter ***
+epsrox = 3.9                  toxe = tox_n                  toxm = tox_n                  
+dtox = 3.15E-10               xj = 8.1E-8                   ndep = 1E17                   
+ngate = 1.6E20                nsd = 1E20                    rsh = 17.5                    
+rshg = 15.5                   
//*** dW and dL Parameter ***
+wint = 2E-9                   wl = 0                        wln = 1                       
+ww = 0                        wwn = 1                       wwl = 0                       
+lint = 1E-9                   ll = 0                        lln = 1                       
+lw = 0                        lwn = 1                       lwl = 0                       
+llc = 0                       lwc = 0                       lwlc = 0                      
+wlc = 0                       wwc = 0                       wwlc = 0                      
+dwg = 0                       dwb = 0                       xl = 0+dxl_n                  
+xw = 0+dxw_n                  
//***Layout-Dependent Parasitics Model Parameter ***
+dmcg = 4E-8                   dmci = 4E-8                   dmdg = 0                      
+dmcgt = 0                     dwj = 0                       xgw = 0                       
+xgl = 0                       ngcon = 1                     
//*** Vth Related  Parameter ***
+vth0 = 0.355781+dvth0_n       lvth0 = -4.49395E-9+dlvth0_n  wvth0 = -1.644125E-9+dwvth0_n 
+pvth0 = 1.330209E-15+dpvth0_n phin = 0                      k1 = 0.30264                  
+k2 = -1.90759E-2              lk2 = 3.594564E-9             wk2 = 3.266382E-9             
+pk2 = -1.782904E-15           k3 = -7.284535                k3b = 2.454986                
